v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 400 260 420 260 { lab=Vout}
N 360 260 400 260 { lab=Vout}
N 220 270 280 270 { lab=Vneg}
N 350 350 380 350 { lab=Vout}
N 380 260 380 350 { lab=Vout}
N 270 350 290 350 { lab=Vneg}
N 270 270 270 350 { lab=Vneg}
N 90 270 160 270 { lab=#net1}
N 650 260 680 260 { lab=#net2}
N 500 250 580 250 { lab=Vflag}
N 740 780 2390 780 { lab=Vflag}
N 2390 760 2390 780 { lab=Vflag}
N 2190 760 2190 780 { lab=Vflag}
N 1970 760 1970 780 { lab=Vflag}
N 1770 760 1770 780 { lab=Vflag}
N 1570 760 1570 780 { lab=Vflag}
N 1370 760 1370 780 { lab=Vflag}
N 1160 760 1160 780 { lab=Vflag}
N 960 760 960 780 { lab=Vflag}
N 960 120 960 140 { lab=#net2}
N 680 260 960 260 { lab=#net2}
N 990 30 1020 30 { lab=#net3}
N 1110 80 1170 80 { lab=Qn0}
N 1170 -60 1170 80 { lab=Qn0}
N 870 -60 1170 -60 { lab=Qn0}
N 870 -60 870 30 { lab=Qn0}
N 870 30 900 30 { lab=Qn0}
N 1080 120 1080 140 { lab=#net4}
N 1080 240 1080 260 { lab=#net2}
N 960 260 1080 260 { lab=#net2}
N 1360 30 1390 30 { lab=#net5}
N 1480 80 1540 80 { lab=Qn1}
N 1540 -60 1540 80 { lab=Qn1}
N 1240 -60 1540 -60 { lab=Qn1}
N 1240 -60 1240 30 { lab=Qn1}
N 1240 30 1270 30 { lab=Qn1}
N 1730 30 1760 30 { lab=#net6}
N 1850 80 1910 80 { lab=Qn2}
N 1910 -60 1910 80 { lab=Qn2}
N 1610 -60 1910 -60 { lab=Qn2}
N 1610 -60 1610 30 { lab=Qn2}
N 1610 30 1640 30 { lab=Qn2}
N 2100 30 2130 30 { lab=#net7}
N 2220 80 2280 80 { lab=Qn3}
N 2280 -60 2280 80 { lab=Qn3}
N 1980 -60 2280 -60 { lab=Qn3}
N 1980 -60 1980 30 { lab=Qn3}
N 1980 30 2010 30 { lab=Qn3}
N 1450 120 1450 260 { lab=Q0}
N 1170 260 1450 260 { lab=Q0}
N 1330 220 1330 260 { lab=Q0}
N 1820 120 1820 260 { lab=Q1}
N 1540 260 1820 260 { lab=Q1}
N 1700 220 1700 260 { lab=Q1}
N 2190 120 2190 260 { lab=Q2}
N 1910 260 2190 260 { lab=Q2}
N 2070 220 2070 260 { lab=Q2}
N 1010 -80 1010 30 { lab=#net3}
N 1370 -80 1370 30 { lab=#net5}
N 1730 -80 1730 30 { lab=#net6}
N 2100 -80 2100 30 { lab=#net7}
N 960 240 960 260 { lab=#net2}
N 960 140 960 240 { lab=#net2}
N 2470 30 2500 30 { lab=#net8}
N 2590 80 2650 80 { lab=Qn4}
N 2650 -60 2650 80 { lab=Qn4}
N 2350 -60 2650 -60 { lab=Qn4}
N 2350 -60 2350 30 { lab=Qn4}
N 2350 30 2380 30 { lab=Qn4}
N 2560 120 2560 260 { lab=Q3}
N 2280 260 2560 260 { lab=Q3}
N 2440 220 2440 260 { lab=Q3}
N 2470 -80 2470 30 { lab=#net8}
N 2840 30 2870 30 { lab=#net9}
N 2960 80 3020 80 { lab=Qn5}
N 3020 -60 3020 80 { lab=Qn5}
N 2720 -60 3020 -60 { lab=Qn5}
N 2720 -60 2720 30 { lab=Qn5}
N 2720 30 2750 30 { lab=Qn5}
N 3210 30 3240 30 { lab=#net10}
N 3330 80 3390 80 { lab=Qn6}
N 3390 -60 3390 80 { lab=Qn6}
N 3090 -60 3390 -60 { lab=Qn6}
N 3090 -60 3090 30 { lab=Qn6}
N 3090 30 3120 30 { lab=Qn6}
N 3580 30 3610 30 { lab=#net11}
N 3700 80 3760 80 { lab=Qn7}
N 3760 -60 3760 80 { lab=Qn7}
N 3460 -60 3760 -60 { lab=Qn7}
N 3460 -60 3460 30 { lab=Qn7}
N 3460 30 3490 30 { lab=Qn7}
N 2930 120 2930 260 { lab=Q4}
N 2650 260 2930 260 { lab=Q4}
N 2810 220 2810 260 { lab=Q4}
N 3300 120 3300 260 { lab=Q5}
N 3020 260 3300 260 { lab=Q5}
N 3180 220 3180 260 { lab=Q5}
N 3670 120 3670 260 { lab=Q6}
N 3390 260 3670 260 { lab=Q6}
N 3550 220 3550 260 { lab=Q6}
N 2850 -80 2850 30 { lab=#net9}
N 3210 -80 3210 30 { lab=#net10}
N 3580 -80 3580 30 { lab=#net11}
N 3940 30 3970 30 { lab=#net12}
N 4060 80 4120 80 { lab=Qn8}
N 4120 -60 4120 80 { lab=Qn8}
N 3820 -60 4120 -60 { lab=Qn8}
N 3820 -60 3820 30 { lab=Qn8}
N 3820 30 3850 30 { lab=Qn8}
N 4030 120 4030 260 { lab=Q7}
N 3750 260 4030 260 { lab=Q7}
N 3910 220 3910 260 { lab=Q7}
N 3940 -80 3940 30 { lab=#net12}
N 350 470 380 470 { lab=Vout}
N 380 350 380 470 { lab=Vout}
N 270 350 270 470 { lab=Vneg}
N 270 470 290 470 { lab=Vneg}
N 820 -390 880 -390 { lab=NP}
N 650 -390 720 -390 { lab=P}
N 380 470 410 470 { lab=Vout}
N 260 850 300 850 { lab=#net13}
N 400 850 460 850 { lab=#net14}
N 460 850 480 850 { lab=#net14}
N 480 810 480 850 { lab=#net14}
N 480 810 560 810 { lab=#net14}
N -20 750 560 750 { lab=#net15}
N 120 850 160 850 { lab=#net16}
N 0 850 20 850 { lab=#net15}
N 0 750 0 850 { lab=#net15}
C {madvlsi/vsource.sym} -460 -120 0 0 {name=Vdd
value=1.8}
C {madvlsi/gnd.sym} -460 -90 0 0 {name=l23 lab=GND}
C {madvlsi/vdd.sym} -460 -150 0 0 {name=l26 lab=VDD}
C {madvlsi/vsource.sym} -250 -120 0 0 {name=Vin
value=1.8}
C {madvlsi/gnd.sym} -250 -90 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} -250 -150 1 0 {name=l14 sig_type=std_logic lab=Vin}
C {devices/code_shown.sym} 70 -230 0 0 {name=SPICE only_toplevel=false value=".tran 10u 10m
.save all"}
C {devices/lab_pin.sym} 380 260 1 0 {name=l2 sig_type=std_logic lab=Vout}
C {madvlsi/tt_models.sym} -460 160 0 0 {
name=TT_MODELS
only_toplevel=false
value=".option wnflag=1
.param MC_SWITCH=0.0
.lib ~/skywater/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/sky130.lib.spice tt"
}
C {devices/lab_pin.sym} 10 250 0 0 {name=l3 sig_type=std_logic lab=Vin}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage.sym} 320 260 0 0 {name=X1}
C {madvlsi/vsource.sym} -350 -120 0 0 {name=Vref
value=0.9}
C {madvlsi/gnd.sym} -350 -90 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} -350 -150 1 0 {name=l4 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 280 250 0 0 {name=l5 sig_type=std_logic lab=Vref}
C {madvlsi/resistor.sym} 190 270 1 0 {name=R1
value=1meg
m=1}
C {madvlsi/capacitor.sym} 320 350 1 0 {name=C1
value=4n
m=1}
C {devices/lab_pin.sym} 250 270 3 0 {name=l6 sig_type=std_logic lab=Vneg}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/transmission_gate.sym} 50 270 0 0 {name=X2}
C {madvlsi/gnd.sym} 10 290 1 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} 420 240 1 0 {name=l9 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 530 250 1 0 {name=l12 sig_type=std_logic lab=Vflag}
C {devices/lab_pin.sym} 580 270 0 0 {name=l10 sig_type=std_logic lab=CLK}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/and2.sym} 550 260 0 0 {name=X6}
C {madvlsi/vdd.sym} 610 230 0 0 {name=l62 lab=VDD}
C {madvlsi/gnd.sym} 610 290 0 0 {name=l63 lab=GND}
C {madvlsi/vsource.sym} -160 -120 0 0 {name=VCLK
value="pulse(0 1.8 0 1n 1n 6u 12u)"}
C {madvlsi/gnd.sym} -160 -90 0 0 {name=l22 lab=GND}
C {devices/lab_pin.sym} -160 -150 1 0 {name=l25 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 50 310 3 0 {name=l8 sig_type=std_logic lab=Q8}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 850 700 0 0 {name=X33}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1050 700 0 0 {name=X34}
C {devices/lab_pin.sym} -20 750 0 0 {name=l64 sig_type=std_logic lab=Vflag}
C {devices/lab_pin.sym} 900 670 0 0 {name=l69 sig_type=std_logic lab=Q0}
C {devices/lab_pin.sym} 1100 670 0 0 {name=l70 sig_type=std_logic lab=Q1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1260 700 0 0 {name=X47}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1460 700 0 0 {name=X48}
C {devices/lab_pin.sym} 1310 670 0 0 {name=l92 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 1510 670 0 0 {name=l93 sig_type=std_logic lab=Q3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1660 700 0 0 {name=X49}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1860 700 0 0 {name=X50}
C {devices/lab_pin.sym} 1710 670 0 0 {name=l94 sig_type=std_logic lab=Q4}
C {devices/lab_pin.sym} 1910 670 0 0 {name=l95 sig_type=std_logic lab=Q5}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 2080 700 0 0 {name=X51}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 2280 700 0 0 {name=X52}
C {devices/lab_pin.sym} 2130 670 0 0 {name=l96 sig_type=std_logic lab=Q6}
C {devices/lab_pin.sym} 2330 670 0 0 {name=l97 sig_type=std_logic lab=Q7}
C {devices/lab_pin.sym} 990 670 2 0 {name=l98 sig_type=std_logic lab=Qout0}
C {devices/lab_pin.sym} 1190 670 2 0 {name=l99 sig_type=std_logic lab=Qout1}
C {devices/lab_pin.sym} 1400 670 2 0 {name=l100 sig_type=std_logic lab=Qout2}
C {devices/lab_pin.sym} 1600 670 2 0 {name=l101 sig_type=std_logic lab=Qout3}
C {devices/lab_pin.sym} 1800 670 2 0 {name=l102 sig_type=std_logic lab=Qout4}
C {devices/lab_pin.sym} 2000 670 2 0 {name=l103 sig_type=std_logic lab=Qout5}
C {devices/lab_pin.sym} 2220 670 2 0 {name=l104 sig_type=std_logic lab=Qout6}
C {devices/lab_pin.sym} 2420 670 2 0 {name=l105 sig_type=std_logic lab=Qout7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/comparator_amp.sym} 460 250 0 0 {name=X3}
C {devices/lab_pin.sym} 1010 -180 1 0 {name=l85 sig_type=std_logic lab=Q0}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 850 60 0 0 {name=X43}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 970 60 0 0 {name=X44}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1080 200 3 0 {name=X45 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 1040 200 3 0 {name=l87 lab=VDD}
C {madvlsi/gnd.sym} 1120 200 3 0 {name=l88 lab=GND}
C {devices/lab_pin.sym} 1370 -180 1 0 {name=l89 sig_type=std_logic lab=Q1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1220 60 0 0 {name=X46}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1340 60 0 0 {name=X53}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1330 180 3 0 {name=X54 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 1290 180 3 0 {name=l90 lab=VDD}
C {madvlsi/gnd.sym} 1370 180 3 0 {name=l91 lab=GND}
C {devices/lab_pin.sym} 1170 80 2 0 {name=l106 sig_type=std_logic lab=Qn0}
C {devices/lab_pin.sym} 1540 80 2 0 {name=l107 sig_type=std_logic lab=Qn1}
C {devices/lab_pin.sym} 1730 -180 1 0 {name=l108 sig_type=std_logic lab=Q2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1590 60 0 0 {name=X55}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1710 60 0 0 {name=X56}
C {devices/lab_pin.sym} 1910 80 2 0 {name=l109 sig_type=std_logic lab=Qn2}
C {devices/lab_pin.sym} 2100 -180 1 0 {name=l110 sig_type=std_logic lab=Q3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1960 60 0 0 {name=X57}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 2080 60 0 0 {name=X58}
C {devices/lab_pin.sym} 2280 80 2 0 {name=l111 sig_type=std_logic lab=Qn3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1700 180 3 0 {name=X61 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 1660 180 3 0 {name=l114 lab=VDD}
C {madvlsi/gnd.sym} 1740 180 3 0 {name=l115 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2070 180 3 0 {name=X62 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 2030 180 3 0 {name=l116 lab=VDD}
C {madvlsi/gnd.sym} 2110 180 3 0 {name=l117 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1010 -120 3 0 {name=X64 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 970 -120 3 0 {name=l120 lab=VDD}
C {madvlsi/gnd.sym} 1050 -120 3 0 {name=l121 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1370 -120 3 0 {name=X65 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 1330 -120 3 0 {name=l122 lab=VDD}
C {madvlsi/gnd.sym} 1410 -120 3 0 {name=l123 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1730 -120 3 0 {name=X66 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 1690 -120 3 0 {name=l124 lab=VDD}
C {madvlsi/gnd.sym} 1770 -120 3 0 {name=l125 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2100 -120 3 0 {name=X67 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 2060 -120 3 0 {name=l126 lab=VDD}
C {madvlsi/gnd.sym} 2140 -120 3 0 {name=l127 lab=GND}
C {devices/lab_pin.sym} 1170 260 0 0 {name=l129 sig_type=std_logic lab=Q0}
C {devices/lab_pin.sym} 1540 260 0 0 {name=l130 sig_type=std_logic lab=Q1}
C {devices/lab_pin.sym} 1910 260 0 0 {name=l131 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 2280 260 0 0 {name=l132 sig_type=std_logic lab=Q3}
C {madvlsi/vsource.sym} 560 -160 0 0 {name=Vdd1
value="pwl(0 0 50u 0 51u 1.8)"}
C {madvlsi/gnd.sym} 560 -130 0 0 {name=l135 lab=GND}
C {madvlsi/vsource.sym} 380 -160 0 0 {name=Vdd2
value=1.8}
C {madvlsi/gnd.sym} 380 -130 0 0 {name=l136 lab=GND}
C {devices/lab_pin.sym} 560 -190 0 0 {name=l137 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 380 -190 0 0 {name=l138 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 900 60 0 0 {name=l139 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 900 90 0 0 {name=l140 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 1020 90 0 0 {name=l141 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 1020 60 0 0 {name=l142 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 1270 60 0 0 {name=l143 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 1270 90 0 0 {name=l144 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 1640 60 0 0 {name=l145 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 1640 90 0 0 {name=l146 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 2010 60 0 0 {name=l147 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 2010 90 0 0 {name=l148 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 1390 90 0 0 {name=l151 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 1390 60 0 0 {name=l152 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 1760 90 0 0 {name=l153 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 1760 60 0 0 {name=l154 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 2130 90 0 0 {name=l155 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 2130 60 0 0 {name=l156 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 2470 -180 1 0 {name=l11 sig_type=std_logic lab=Q4}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 2330 60 0 0 {name=X4}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 2450 60 0 0 {name=X5}
C {devices/lab_pin.sym} 2650 80 2 0 {name=l15 sig_type=std_logic lab=Qn4}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2440 180 3 0 {name=X7 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 2400 180 3 0 {name=l16 lab=VDD}
C {madvlsi/gnd.sym} 2480 180 3 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} 2280 260 0 0 {name=l18 sig_type=std_logic lab=Q3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2470 -120 3 0 {name=X8 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 2430 -120 3 0 {name=l19 lab=VDD}
C {madvlsi/gnd.sym} 2510 -120 3 0 {name=l20 lab=GND}
C {devices/lab_pin.sym} 2380 60 0 0 {name=l21 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 2380 90 0 0 {name=l24 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 2500 90 0 0 {name=l27 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 2500 60 0 0 {name=l28 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 2850 -180 1 0 {name=l29 sig_type=std_logic lab=Q5}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 2700 60 0 0 {name=X9}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 2820 60 0 0 {name=X10}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2810 180 3 0 {name=X11 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 2770 180 3 0 {name=l30 lab=VDD}
C {madvlsi/gnd.sym} 2850 180 3 0 {name=l31 lab=GND}
C {devices/lab_pin.sym} 3020 80 2 0 {name=l32 sig_type=std_logic lab=Qn5}
C {devices/lab_pin.sym} 3210 -180 1 0 {name=l33 sig_type=std_logic lab=Q6}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 3070 60 0 0 {name=X12}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 3190 60 0 0 {name=X13}
C {devices/lab_pin.sym} 3390 80 2 0 {name=l34 sig_type=std_logic lab=Qn6}
C {devices/lab_pin.sym} 3580 -180 1 0 {name=l35 sig_type=std_logic lab=Q7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 3440 60 0 0 {name=X14}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 3560 60 0 0 {name=X15}
C {devices/lab_pin.sym} 3760 80 2 0 {name=l36 sig_type=std_logic lab=Qn7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3180 180 3 0 {name=X18 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 3140 180 3 0 {name=l39 lab=VDD}
C {madvlsi/gnd.sym} 3220 180 3 0 {name=l40 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3550 180 3 0 {name=X19 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 3510 180 3 0 {name=l41 lab=VDD}
C {madvlsi/gnd.sym} 3590 180 3 0 {name=l42 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2850 -120 3 0 {name=X21 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 2810 -120 3 0 {name=l45 lab=VDD}
C {madvlsi/gnd.sym} 2890 -120 3 0 {name=l46 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3210 -120 3 0 {name=X22 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 3170 -120 3 0 {name=l47 lab=VDD}
C {madvlsi/gnd.sym} 3250 -120 3 0 {name=l48 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3580 -120 3 0 {name=X23 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 3540 -120 3 0 {name=l49 lab=VDD}
C {madvlsi/gnd.sym} 3620 -120 3 0 {name=l50 lab=GND}
C {devices/lab_pin.sym} 2650 260 0 0 {name=l51 sig_type=std_logic lab=Q4}
C {devices/lab_pin.sym} 3020 260 0 0 {name=l52 sig_type=std_logic lab=Q5}
C {devices/lab_pin.sym} 3390 260 0 0 {name=l53 sig_type=std_logic lab=Q6}
C {devices/lab_pin.sym} 2750 60 0 0 {name=l57 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 2750 90 0 0 {name=l58 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 3120 60 0 0 {name=l59 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 3120 90 0 0 {name=l60 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 3490 60 0 0 {name=l61 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 3490 90 0 0 {name=l65 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 2870 90 0 0 {name=l68 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 2870 60 0 0 {name=l71 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 3240 90 0 0 {name=l72 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 3240 60 0 0 {name=l73 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 3610 90 0 0 {name=l74 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 3610 60 0 0 {name=l75 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 3940 -180 1 0 {name=l37 sig_type=std_logic lab=Q8}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 3800 60 0 0 {name=X16}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 3920 60 0 0 {name=X17}
C {devices/lab_pin.sym} 4120 80 2 0 {name=l38 sig_type=std_logic lab=Qn8}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3910 180 3 0 {name=X20 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 3870 180 3 0 {name=l43 lab=VDD}
C {madvlsi/gnd.sym} 3950 180 3 0 {name=l44 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3940 -120 3 0 {name=X24 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 3900 -120 3 0 {name=l54 lab=VDD}
C {madvlsi/gnd.sym} 3980 -120 3 0 {name=l55 lab=GND}
C {devices/lab_pin.sym} 3750 260 0 0 {name=l56 sig_type=std_logic lab=Q7}
C {devices/lab_pin.sym} 3850 60 0 0 {name=l66 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 3850 90 0 0 {name=l67 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 3970 90 0 0 {name=l76 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 3970 60 0 0 {name=l77 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 900 700 0 0 {name=l78 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 900 730 0 0 {name=l79 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 1100 700 0 0 {name=l80 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 1100 730 0 0 {name=l81 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 1310 700 0 0 {name=l82 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 1310 730 0 0 {name=l83 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 1510 700 0 0 {name=l84 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 1510 730 0 0 {name=l86 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 1710 700 0 0 {name=l128 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 1710 730 0 0 {name=l159 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 1910 700 0 0 {name=l160 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 1910 730 0 0 {name=l161 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 2130 700 0 0 {name=l162 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 2130 730 0 0 {name=l163 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 2330 700 0 0 {name=l164 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 2330 730 0 0 {name=l165 sig_type=std_logic lab=C}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 320 470 0 0 {name=X25 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {devices/lab_pin.sym} 330 490 3 0 {name=l112 sig_type=std_logic lab=P}
C {madvlsi/gnd.sym} 760 -350 0 0 {name=l113 lab=GND}
C {devices/lab_pin.sym} 650 -390 0 0 {name=l118 sig_type=std_logic lab=P}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 760 -390 0 0 {name=X26 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {devices/lab_pin.sym} 880 -390 2 0 {name=l119 sig_type=std_logic lab=NP}
C {madvlsi/vdd.sym} 760 -430 0 0 {name=l133 lab=VDD}
C {devices/lab_pin.sym} 310 490 3 0 {name=l134 sig_type=std_logic lab=NP}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 440 470 0 0 {name=X27 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {devices/lab_pin.sym} 470 470 2 0 {name=l149 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 450 490 3 0 {name=l150 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 430 490 3 0 {name=l157 sig_type=std_logic lab=NP}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 200 850 0 0 {name=X28 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 340 850 0 0 {name=X29 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 340 810 0 0 {name=l167 lab=VDD}
C {madvlsi/gnd.sym} 340 890 0 0 {name=l168 lab=GND}
C {madvlsi/vdd.sym} 200 810 0 0 {name=l169 lab=VDD}
C {madvlsi/gnd.sym} 200 890 0 0 {name=l170 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/nor2.sym} 640 780 0 0 {name=X30 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 60 850 0 0 {name=X31 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 60 810 0 0 {name=l171 lab=VDD}
C {madvlsi/gnd.sym} 60 890 0 0 {name=l172 lab=GND}
