v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 400 260 420 260 { lab=Vout}
N 360 260 400 260 { lab=Vout}
N 220 270 280 270 { lab=Vneg}
N 350 350 380 350 { lab=Vout}
N 380 260 380 350 { lab=Vout}
N 270 350 290 350 { lab=Vneg}
N 270 270 270 350 { lab=Vneg}
N 90 270 160 270 { lab=#net1}
N 650 260 680 260 { lab=#net2}
N 680 260 680 340 { lab=#net2}
N 870 320 870 340 { lab=#net2}
N 900 230 930 230 { lab=#net3}
N 1020 280 1080 280 { lab=Qn0}
N 1080 140 1080 280 { lab=Qn0}
N 780 140 1080 140 { lab=Qn0}
N 780 140 780 230 { lab=Qn0}
N 780 230 810 230 { lab=Qn0}
N 990 320 990 340 { lab=#net4}
N 990 440 990 460 { lab=#net2}
N 870 460 990 460 { lab=#net2}
N 870 340 870 460 { lab=#net2}
N 1270 230 1300 230 { lab=#net5}
N 1390 280 1450 280 { lab=Qn1}
N 1450 140 1450 280 { lab=Qn1}
N 1150 140 1450 140 { lab=Qn1}
N 1150 140 1150 230 { lab=Qn1}
N 1150 230 1180 230 { lab=Qn1}
N 1640 230 1670 230 { lab=#net6}
N 1760 280 1820 280 { lab=Qn2}
N 1820 140 1820 280 { lab=Qn2}
N 1520 140 1820 140 { lab=Qn2}
N 1520 140 1520 230 { lab=Qn2}
N 1520 230 1550 230 { lab=Qn2}
N 2010 230 2040 230 { lab=#net7}
N 2130 280 2190 280 { lab=Qn3}
N 2190 140 2190 280 { lab=Qn3}
N 1890 140 2190 140 { lab=Qn3}
N 1890 140 1890 230 { lab=Qn3}
N 1890 230 1920 230 { lab=Qn3}
N 2380 230 2410 230 { lab=#net8}
N 2500 280 2560 280 { lab=Qn4}
N 2260 140 2560 140 { lab=Qn4}
N 2260 140 2260 230 { lab=Qn4}
N 2260 230 2290 230 { lab=Qn4}
N 1360 320 1360 460 { lab=Q0}
N 1240 420 1240 460 { lab=Q0}
N 1730 320 1730 460 { lab=Q1}
N 1610 420 1610 460 { lab=Q1}
N 2100 320 2100 460 { lab=Q2}
N 1980 420 1980 460 { lab=Q2}
N 2470 320 2470 460 { lab=Q3}
N 2350 420 2350 460 { lab=Q3}
N 920 120 920 230 { lab=#net3}
N 1280 120 1280 230 { lab=#net5}
N 1640 120 1640 230 { lab=#net6}
N 2010 120 2010 230 { lab=#net7}
N 2380 120 2380 230 { lab=#net8}
N 680 340 870 340 { lab=#net2}
N 2560 140 2560 280 { lab=Qn4}
N 2750 230 2780 230 { lab=#net9}
N 2870 280 2930 280 { lab=Qn5}
N 2930 140 2930 280 { lab=Qn5}
N 2630 140 2930 140 { lab=Qn5}
N 2630 140 2630 230 { lab=Qn5}
N 2630 230 2660 230 { lab=Qn5}
N 2840 320 2840 460 { lab=Q4}
N 2720 420 2720 460 { lab=Q4}
N 2750 120 2750 230 { lab=#net9}
N 1160 460 1360 460 { lab=Q0}
N 1530 460 1730 460 { lab=Q1}
N 1900 460 2100 460 { lab=Q2}
N 2270 460 2470 460 { lab=Q3}
N 2640 460 2840 460 { lab=Q4}
N 500 250 580 250 { lab=Vflag}
N 3130 230 3160 230 { lab=#net10}
N 3250 280 3310 280 { lab=Qn6}
N 3310 140 3310 280 { lab=Qn6}
N 3010 140 3310 140 { lab=Qn6}
N 3010 140 3010 230 { lab=Qn6}
N 3010 230 3040 230 { lab=Qn6}
N 3220 320 3220 460 { lab=Q5}
N 3100 420 3100 460 { lab=Q5}
N 3130 120 3130 230 { lab=#net10}
N 3020 460 3220 460 { lab=Q5}
N 3540 230 3570 230 { lab=#net11}
N 3660 280 3720 280 { lab=Qn7}
N 3720 140 3720 280 { lab=Qn7}
N 3420 140 3720 140 { lab=Qn7}
N 3420 140 3420 230 { lab=Qn7}
N 3420 230 3450 230 { lab=Qn7}
N 3630 320 3630 460 { lab=Q6}
N 3510 420 3510 460 { lab=Q6}
N 3540 120 3540 230 { lab=#net11}
N 3430 460 3630 460 { lab=Q6}
N 3960 230 3990 230 { lab=#net12}
N 4080 280 4140 280 { lab=Qn8}
N 4140 140 4140 280 { lab=Qn8}
N 3840 140 4140 140 { lab=Qn8}
N 3840 140 3840 230 { lab=Qn8}
N 3840 230 3870 230 { lab=Qn8}
N 4050 320 4050 460 { lab=Q7}
N 3930 420 3930 460 { lab=Q7}
N 3960 120 3960 230 { lab=#net12}
N 3850 460 4050 460 { lab=Q7}
N 740 780 2390 780 { lab=Vflag}
N 2390 760 2390 780 { lab=Vflag}
N 2190 760 2190 780 { lab=Vflag}
N 1970 760 1970 780 { lab=Vflag}
N 1770 760 1770 780 { lab=Vflag}
N 1570 760 1570 780 { lab=Vflag}
N 1370 760 1370 780 { lab=Vflag}
N 1160 760 1160 780 { lab=Vflag}
N 960 760 960 780 { lab=Vflag}
C {madvlsi/vsource.sym} -260 0 0 0 {name=Vdd
value=1.8}
C {madvlsi/gnd.sym} -260 30 0 0 {name=l23 lab=GND}
C {madvlsi/vdd.sym} -260 -30 0 0 {name=l26 lab=VDD}
C {madvlsi/vsource.sym} -50 0 0 0 {name=Vin
value=1.5}
C {madvlsi/gnd.sym} -50 30 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} -50 -30 1 0 {name=l14 sig_type=std_logic lab=Vin}
C {devices/code_shown.sym} 70 -230 0 0 {name=SPICE only_toplevel=false value=".tran 0.1u 10m
.ic v(Q0)=0 v(Qn0)=1.8
.ic v(Q1)=0 v(Qn1)=0
.ic v(Q2)=0 v(Qn2)=0
.ic v(Q3)=0 v(Qn3)=0
.ic v(Q4)=0 v(Qn4)=0
.ic v(Q5)=0 v(Qn5)=0
.ic v(Q6)=0 v(Qn6)=0
.ic v(Q7)=0 v(Qn7)=0
.ic v(Q8)=0 v(Qn8)=0
.ic v(Vout)=0.9 v(Vneg)=0.9
.save all"}
C {devices/lab_pin.sym} 380 260 1 0 {name=l2 sig_type=std_logic lab=Vout}
C {madvlsi/tt_models.sym} -460 160 0 0 {
name=TT_MODELS
only_toplevel=false
value=".option wnflag=1
.param MC_SWITCH=0.0
.lib ~/skywater/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/sky130.lib.spice tt"
}
C {devices/lab_pin.sym} 10 250 0 0 {name=l3 sig_type=std_logic lab=Vin}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage.sym} 320 260 0 0 {name=X1}
C {madvlsi/vsource.sym} -150 0 0 0 {name=Vref
value=0.9}
C {madvlsi/gnd.sym} -150 30 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} -150 -30 1 0 {name=l4 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 280 250 0 0 {name=l5 sig_type=std_logic lab=Vref}
C {madvlsi/resistor.sym} 190 270 1 0 {name=R1
value=1meg
m=1}
C {madvlsi/capacitor.sym} 320 350 1 0 {name=C1
value=4n
m=1}
C {devices/lab_pin.sym} 250 270 3 0 {name=l6 sig_type=std_logic lab=Vneg}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/transmission_gate.sym} 50 270 0 0 {name=X2}
C {madvlsi/gnd.sym} 10 290 1 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} 420 240 1 0 {name=l9 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 530 250 1 0 {name=l12 sig_type=std_logic lab=Vflag}
C {devices/lab_pin.sym} 580 270 0 0 {name=l10 sig_type=std_logic lab=CLK}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/and2.sym} 550 260 0 0 {name=X6}
C {madvlsi/vdd.sym} 610 230 0 0 {name=l62 lab=VDD}
C {madvlsi/gnd.sym} 610 290 0 0 {name=l63 lab=GND}
C {devices/lab_pin.sym} 920 20 2 0 {name=l40 sig_type=std_logic lab=Q0}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 760 260 0 0 {name=X4}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 880 260 0 0 {name=X5}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 990 400 3 0 {name=X7 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 950 400 3 0 {name=l11 lab=VDD}
C {madvlsi/gnd.sym} 1030 400 3 0 {name=l15 lab=GND}
C {devices/lab_pin.sym} 1280 20 2 0 {name=l16 sig_type=std_logic lab=Q1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1130 260 0 0 {name=X8}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1250 260 0 0 {name=X9}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1240 380 3 0 {name=X10 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 1200 380 3 0 {name=l18 lab=VDD}
C {madvlsi/gnd.sym} 1280 380 3 0 {name=l19 lab=GND}
C {devices/lab_pin.sym} 1080 280 2 0 {name=l20 sig_type=std_logic lab=Qn0}
C {devices/lab_pin.sym} 1450 280 2 0 {name=l21 sig_type=std_logic lab=Qn1}
C {devices/lab_pin.sym} 1640 20 2 0 {name=l24 sig_type=std_logic lab=Q2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1500 260 0 0 {name=X11}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1620 260 0 0 {name=X12}
C {devices/lab_pin.sym} 1820 280 2 0 {name=l27 sig_type=std_logic lab=Qn2}
C {devices/lab_pin.sym} 2010 20 2 0 {name=l28 sig_type=std_logic lab=Q3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1870 260 0 0 {name=X13}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1990 260 0 0 {name=X14}
C {devices/lab_pin.sym} 2190 280 2 0 {name=l29 sig_type=std_logic lab=Qn3}
C {devices/lab_pin.sym} 2380 20 2 0 {name=l30 sig_type=std_logic lab=Q4}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 2240 260 0 0 {name=X15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 2360 260 0 0 {name=X16}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1610 380 3 0 {name=X17 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 1570 380 3 0 {name=l32 lab=VDD}
C {madvlsi/gnd.sym} 1650 380 3 0 {name=l33 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1980 380 3 0 {name=X18 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 1940 380 3 0 {name=l34 lab=VDD}
C {madvlsi/gnd.sym} 2020 380 3 0 {name=l35 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2350 380 3 0 {name=X19 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 2310 380 3 0 {name=l36 lab=VDD}
C {madvlsi/gnd.sym} 2390 380 3 0 {name=l37 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 920 80 3 0 {name=X20 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 880 80 3 0 {name=l38 lab=VDD}
C {madvlsi/gnd.sym} 960 80 3 0 {name=l41 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1280 80 3 0 {name=X21 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 1240 80 3 0 {name=l42 lab=VDD}
C {madvlsi/gnd.sym} 1320 80 3 0 {name=l43 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1640 80 3 0 {name=X23 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 1600 80 3 0 {name=l44 lab=VDD}
C {madvlsi/gnd.sym} 1680 80 3 0 {name=l45 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2010 80 3 0 {name=X24 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 1970 80 3 0 {name=l46 lab=VDD}
C {madvlsi/gnd.sym} 2050 80 3 0 {name=l47 lab=GND}
C {devices/lab_pin.sym} 1160 460 0 0 {name=l48 sig_type=std_logic lab=Q0}
C {devices/lab_pin.sym} 1530 460 0 0 {name=l49 sig_type=std_logic lab=Q1}
C {devices/lab_pin.sym} 1900 460 0 0 {name=l50 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 2270 460 0 0 {name=l51 sig_type=std_logic lab=Q3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2380 80 3 0 {name=X25 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 2340 80 3 0 {name=l52 lab=VDD}
C {madvlsi/gnd.sym} 2420 80 3 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} 2560 280 2 0 {name=l17 sig_type=std_logic lab=Qn4}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 2610 260 0 0 {name=X26}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 2730 260 0 0 {name=X27}
C {devices/lab_pin.sym} 2930 280 2 0 {name=l55 sig_type=std_logic lab=Qn5}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2720 380 3 0 {name=X28 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 2680 380 3 0 {name=l56 lab=VDD}
C {madvlsi/gnd.sym} 2760 380 3 0 {name=l65 lab=GND}
C {devices/lab_pin.sym} 2640 460 0 0 {name=l66 sig_type=std_logic lab=Q4}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2750 80 3 0 {name=X29 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 2710 80 3 0 {name=l67 lab=VDD}
C {madvlsi/gnd.sym} 2790 80 3 0 {name=l68 lab=GND}
C {devices/lab_pin.sym} 920 20 2 0 {name=l54 sig_type=std_logic lab=Q0}
C {madvlsi/vdd.sym} 880 80 3 0 {name=l128 lab=VDD}
C {devices/lab_pin.sym} 2750 20 2 0 {name=l209 sig_type=std_logic lab=Q5}
C {madvlsi/vsource.sym} 40 0 0 0 {name=VCLK
value="pulse(0 1.8 0 1n 1n 5u 10u)"}
C {madvlsi/gnd.sym} 40 30 0 0 {name=l22 lab=GND}
C {devices/lab_pin.sym} 40 -30 1 0 {name=l25 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 50 310 3 0 {name=l8 sig_type=std_logic lab=Q8}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 2990 260 0 0 {name=X22}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 3110 260 0 0 {name=X30}
C {devices/lab_pin.sym} 3310 280 2 0 {name=l31 sig_type=std_logic lab=Qn6}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3100 380 3 0 {name=X31 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 3060 380 3 0 {name=l39 lab=VDD}
C {madvlsi/gnd.sym} 3140 380 3 0 {name=l57 lab=GND}
C {devices/lab_pin.sym} 3020 460 0 0 {name=l58 sig_type=std_logic lab=Q5}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3130 80 3 0 {name=X32 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 3090 80 3 0 {name=l59 lab=VDD}
C {madvlsi/gnd.sym} 3170 80 3 0 {name=l60 lab=GND}
C {devices/lab_pin.sym} 3130 20 2 0 {name=l61 sig_type=std_logic lab=Q6}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 850 700 0 0 {name=X33}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1050 700 0 0 {name=X34}
C {devices/lab_pin.sym} 740 780 0 0 {name=l64 sig_type=std_logic lab=Vflag}
C {devices/lab_pin.sym} 900 670 0 0 {name=l69 sig_type=std_logic lab=Q0}
C {devices/lab_pin.sym} 1100 670 0 0 {name=l70 sig_type=std_logic lab=Q1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 3400 260 0 0 {name=X35}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 3520 260 0 0 {name=X36}
C {devices/lab_pin.sym} 3720 280 2 0 {name=l71 sig_type=std_logic lab=Qn7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3510 380 3 0 {name=X37 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 3470 380 3 0 {name=l72 lab=VDD}
C {madvlsi/gnd.sym} 3550 380 3 0 {name=l73 lab=GND}
C {devices/lab_pin.sym} 3430 460 0 0 {name=l74 sig_type=std_logic lab=Q6}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3540 80 3 0 {name=X38 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 3500 80 3 0 {name=l75 lab=VDD}
C {madvlsi/gnd.sym} 3580 80 3 0 {name=l76 lab=GND}
C {devices/lab_pin.sym} 3540 20 2 0 {name=l77 sig_type=std_logic lab=Q7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 3820 260 0 0 {name=X39}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 3940 260 0 0 {name=X40}
C {devices/lab_pin.sym} 4140 280 2 0 {name=l78 sig_type=std_logic lab=Qn8}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3930 380 3 0 {name=X41 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 3890 380 3 0 {name=l79 lab=VDD}
C {madvlsi/gnd.sym} 3970 380 3 0 {name=l80 lab=GND}
C {devices/lab_pin.sym} 3850 460 0 0 {name=l81 sig_type=std_logic lab=Q7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3960 80 3 0 {name=X42 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 3920 80 3 0 {name=l82 lab=VDD}
C {madvlsi/gnd.sym} 4000 80 3 0 {name=l83 lab=GND}
C {devices/lab_pin.sym} 3960 20 2 0 {name=l84 sig_type=std_logic lab=Q8}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1260 700 0 0 {name=X47}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1460 700 0 0 {name=X48}
C {devices/lab_pin.sym} 1310 670 0 0 {name=l92 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 1510 670 0 0 {name=l93 sig_type=std_logic lab=Q3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1660 700 0 0 {name=X49}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 1860 700 0 0 {name=X50}
C {devices/lab_pin.sym} 1710 670 0 0 {name=l94 sig_type=std_logic lab=Q4}
C {devices/lab_pin.sym} 1910 670 0 0 {name=l95 sig_type=std_logic lab=Q5}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 2080 700 0 0 {name=X51}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 2280 700 0 0 {name=X52}
C {devices/lab_pin.sym} 2130 670 0 0 {name=l96 sig_type=std_logic lab=Q6}
C {devices/lab_pin.sym} 2330 670 0 0 {name=l97 sig_type=std_logic lab=Q7}
C {devices/lab_pin.sym} 990 670 2 0 {name=l98 sig_type=std_logic lab=Qout0}
C {devices/lab_pin.sym} 1190 670 2 0 {name=l99 sig_type=std_logic lab=Qout1}
C {devices/lab_pin.sym} 1400 670 2 0 {name=l100 sig_type=std_logic lab=Qout2}
C {devices/lab_pin.sym} 1600 670 2 0 {name=l101 sig_type=std_logic lab=Qout3}
C {devices/lab_pin.sym} 1800 670 2 0 {name=l102 sig_type=std_logic lab=Qout4}
C {devices/lab_pin.sym} 2000 670 2 0 {name=l103 sig_type=std_logic lab=Qout5}
C {devices/lab_pin.sym} 2220 670 2 0 {name=l104 sig_type=std_logic lab=Qout6}
C {devices/lab_pin.sym} 2420 670 2 0 {name=l105 sig_type=std_logic lab=Qout7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/comparator_amp.sym} 460 250 0 0 {name=X3}
