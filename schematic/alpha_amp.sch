v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
L 4 340 170 730 170 {}
L 4 740 40 1130 40 {}
L 4 1130 40 1130 360 {}
L 4 740 40 740 360 {}
L 4 740 360 1130 360 {}
L 4 1170 40 1560 40 {}
L 4 1560 40 1560 360 {}
L 4 1170 40 1170 360 {}
L 4 1170 360 1560 360 {}
L 4 340 -490 730 -490 {}
L 4 730 -490 730 -170 {}
L 4 340 -490 340 -170 {}
L 4 340 -170 730 -170 {}
L 4 340 -830 730 -830 {}
L 4 340 -530 730 -530 {}
L 4 1090 -1040 1090 -720 {}
L 4 750 -1040 750 -720 {}
L 4 750 -1040 1090 -1040 {}
L 4 750 -720 1090 -720 {}
L 4 1170 -1040 1560 -1040 {}
L 4 1560 -1040 1560 -720 {}
L 4 1170 -1040 1170 -720 {}
L 4 1170 -720 1560 -720 {}
L 4 340 -830 340 -530 {}
L 4 730 -830 730 -530 {}
L 4 340 -130 730 -130 {}
L 4 340 -130 340 170 {}
L 4 730 -130 730 170 {}
N 300 200 760 200 { lab=#net1}
N 760 140 760 200 { lab=#net1}
N 760 140 780 140 { lab=#net1}
N 760 200 760 270 { lab=#net1}
N 760 270 780 270 { lab=#net1}
N 840 140 860 140 { lab=#net2}
N 860 140 860 270 { lab=#net2}
N 840 270 860 270 { lab=#net2}
N 920 190 920 200 { lab=#net2}
N 980 140 1000 140 { lab=#net2}
N 980 140 980 270 { lab=#net2}
N 980 270 1000 270 { lab=#net2}
N 1060 140 1080 140 { lab=#net3}
N 1080 140 1080 270 { lab=#net3}
N 1060 270 1080 270 { lab=#net3}
N 1200 140 1200 200 { lab=#net3}
N 1200 140 1220 140 { lab=#net3}
N 1200 200 1200 270 { lab=#net3}
N 1200 270 1220 270 { lab=#net3}
N 1280 140 1300 140 { lab=#net4}
N 1300 140 1300 270 { lab=#net4}
N 1280 270 1300 270 { lab=#net4}
N 1420 140 1440 140 { lab=#net4}
N 1420 140 1420 270 { lab=#net4}
N 1420 270 1440 270 { lab=#net4}
N 1500 140 1520 140 { lab=GND}
N 1520 140 1520 270 { lab=GND}
N 1500 270 1520 270 { lab=GND}
N 440 140 440 150 { lab=#net1}
N 440 150 580 150 { lab=#net1}
N 580 140 580 150 { lab=#net1}
N 510 150 510 200 { lab=#net1}
N 440 70 440 80 { lab=#net5}
N 440 70 580 70 { lab=#net5}
N 580 70 580 80 { lab=#net5}
N 440 -40 440 -30 { lab=#net5}
N 440 -30 580 -30 { lab=#net5}
N 580 -40 580 -30 { lab=#net5}
N 510 -30 510 70 { lab=#net5}
N 1080 200 1200 200 { lab=#net3}
N 760 -940 760 -880 { lab=#net6}
N 760 -940 780 -940 { lab=#net6}
N 760 -880 760 -810 { lab=#net6}
N 760 -810 780 -810 { lab=#net6}
N 840 -940 860 -940 { lab=#net7}
N 860 -940 860 -810 { lab=#net7}
N 840 -810 860 -810 { lab=#net7}
N 920 -890 920 -880 { lab=#net7}
N 980 -940 1000 -940 { lab=#net7}
N 980 -940 980 -810 { lab=#net7}
N 980 -810 1000 -810 { lab=#net7}
N 1060 -940 1080 -940 { lab=#net8}
N 1080 -940 1080 -810 { lab=#net8}
N 1060 -810 1080 -810 { lab=#net8}
N 1200 -940 1200 -880 { lab=#net8}
N 1200 -940 1220 -940 { lab=#net8}
N 1200 -880 1200 -810 { lab=#net8}
N 1200 -810 1220 -810 { lab=#net8}
N 1280 -940 1300 -940 { lab=#net9}
N 1300 -940 1300 -810 { lab=#net9}
N 1280 -810 1300 -810 { lab=#net9}
N 1420 -940 1440 -940 { lab=#net9}
N 1420 -940 1420 -810 { lab=#net9}
N 1420 -810 1440 -810 { lab=#net9}
N 1510 -940 1510 -810 { lab=#net10}
N 1080 -880 1200 -880 { lab=#net8}
N 1300 -890 1420 -890 { lab=#net9}
N 1360 -890 1360 -880 { lab=#net9}
N 860 -890 980 -890 { lab=#net7}
N 860 190 980 190 { lab=#net2}
N 1300 190 1420 190 { lab=#net4}
N 1360 190 1360 200 { lab=#net4}
N 440 -110 440 -100 { lab=#net11}
N 440 -110 580 -110 { lab=#net11}
N 580 -110 580 -100 { lab=#net11}
N 440 -210 440 -200 { lab=#net11}
N 440 -200 580 -200 { lab=#net11}
N 580 -210 580 -200 { lab=#net11}
N 510 -200 510 -110 { lab=#net11}
N 440 -390 440 -380 { lab=#net12}
N 440 -380 580 -380 { lab=#net12}
N 580 -390 580 -380 { lab=#net12}
N 440 -280 440 -270 { lab=#net12}
N 440 -280 580 -280 { lab=#net12}
N 580 -280 580 -270 { lab=#net12}
N 510 -380 510 -280 { lab=#net12}
N 440 -460 440 -450 { lab=#net13}
N 440 -460 580 -460 { lab=#net13}
N 580 -460 580 -450 { lab=#net13}
N 440 -570 440 -560 { lab=#net13}
N 440 -560 580 -560 { lab=#net13}
N 580 -570 580 -560 { lab=#net13}
N 510 -560 510 -460 { lab=#net13}
N 440 -750 440 -740 { lab=#net14}
N 440 -740 580 -740 { lab=#net14}
N 580 -750 580 -740 { lab=#net14}
N 440 -640 440 -630 { lab=#net14}
N 440 -640 580 -640 { lab=#net14}
N 580 -640 580 -630 { lab=#net14}
N 510 -740 510 -640 { lab=#net14}
N 300 -860 760 -860 { lab=#net6}
N 440 -820 440 -810 { lab=#net6}
N 440 -820 580 -820 { lab=#net6}
N 580 -820 580 -810 { lab=#net6}
N 510 -860 510 -820 { lab=#net6}
N 1500 -810 1510 -810 { lab=#net10}
N 1500 -940 1510 -940 { lab=#net10}
N 80 -830 120 -830 { lab=#net13}
N 80 -830 80 -510 { lab=#net13}
N 80 -510 510 -510 { lab=#net13}
N 80 -150 510 -150 { lab=#net11}
N 80 -150 80 230 { lab=#net11}
N 80 230 120 230 { lab=#net11}
N 40 170 120 170 { lab=#net15}
N 40 -890 120 -890 { lab=#net16}
N 1150 -340 1150 200 { lab=#net3}
N 1150 -340 1280 -340 { lab=#net3}
N 1150 -880 1150 -400 { lab=#net8}
N 1150 -400 1280 -400 { lab=#net8}
N 1460 -370 1740 -370 { lab=#net10}
N 1510 -870 1620 -870 { lab=#net10}
N 1620 -870 1620 -370 { lab=#net10}
N 1520 200 1620 200 { lab=GND}
N 1620 200 1620 230 { lab=GND}
N 680 -350 680 -340 { lab=#net12}
N 510 -350 680 -350 { lab=#net12}
N 680 -710 680 -700 { lab=#net14}
N 510 -710 680 -710 { lab=#net14}
N 680 -0 680 10 {}
N 510 -0 680 -0 {}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/diff_amp.sym} 90 -860 0 0 {name=X1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/diff_amp.sym} 90 200 0 0 {name=X2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/diff_amp.sym} 1250 -370 0 0 {name=X3}
C {madvlsi/gnd.sym} 200 300 0 0 {name=l1 lab=GND}
C {madvlsi/gnd.sym} 1360 -270 0 0 {name=l2 lab=GND}
C {madvlsi/gnd.sym} 200 -760 0 0 {name=l3 lab=GND}
C {madvlsi/vdd.sym} 200 -960 0 0 {name=l4 lab=VDD}
C {madvlsi/vdd.sym} 1360 -470 0 0 {name=l5 lab=VDD}
C {madvlsi/vdd.sym} 200 100 0 0 {name=l6 lab=VDD}
C {madvlsi/pmos3.sym} 440 -420 0 0 {name=M1
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 580 -420 2 0 {name=M2
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/capacitor.sym} 680 -310 0 0 {name=C1
value=1p
m=1}
C {madvlsi/pmos3.sym} 440 -240 0 0 {name=M3
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 580 -240 2 0 {name=M4
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 440 -780 0 0 {name=M5
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 580 -780 2 0 {name=M6
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/capacitor.sym} 680 -670 0 0 {name=C2
value=1p
m=1}
C {madvlsi/pmos3.sym} 440 -600 0 0 {name=M7
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 580 -600 2 0 {name=M8
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 440 -70 0 0 {name=M9
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 580 -70 2 0 {name=M10
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/capacitor.sym} 680 40 0 0 {name=C3
value=1p
m=1}
C {madvlsi/pmos3.sym} 440 110 0 0 {name=M11
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 580 110 2 0 {name=M12
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 810 -940 1 0 {name=M13
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 810 -810 3 0 {name=M14
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/capacitor.sym} 920 -850 0 0 {name=C4
value=1p
m=1}
C {madvlsi/pmos3.sym} 1030 -940 1 0 {name=M15
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1030 -810 3 0 {name=M16
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1250 -940 1 0 {name=M17
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1250 -810 3 0 {name=M18
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/capacitor.sym} 1360 -850 0 0 {name=C5
value=1p
m=1}
C {madvlsi/pmos3.sym} 1470 -940 1 0 {name=M19
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1470 -810 3 0 {name=M20
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 810 140 1 0 {name=M21
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 810 270 3 0 {name=M22
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/capacitor.sym} 920 230 0 0 {name=C6
value=1p
m=1}
C {madvlsi/pmos3.sym} 1030 140 1 0 {name=M23
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1030 270 3 0 {name=M24
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1250 140 1 0 {name=M25
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1250 270 3 0 {name=M26
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/capacitor.sym} 1360 230 0 0 {name=C7
value=1p
m=1}
C {madvlsi/pmos3.sym} 1470 140 1 0 {name=M27
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1470 270 3 0 {name=M28
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 680 -280 0 0 {name=l7 lab=GND}
C {madvlsi/gnd.sym} 680 70 0 0 {name=l8 lab=GND}
C {madvlsi/gnd.sym} 680 -640 0 0 {name=l9 lab=GND}
C {madvlsi/gnd.sym} 920 -820 0 0 {name=l10 lab=GND}
C {madvlsi/gnd.sym} 1360 -820 0 0 {name=l11 lab=GND}
C {madvlsi/gnd.sym} 920 260 0 0 {name=l12 lab=GND}
C {madvlsi/gnd.sym} 1360 260 0 0 {name=l13 lab=GND}
C {madvlsi/gnd.sym} 1620 230 0 0 {name=l14 lab=GND}
