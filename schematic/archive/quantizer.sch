v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 4390 -1260 4560 -1260 { lab=#net1}
N 4390 -1260 4390 -1180 { lab=#net1}
N 4390 -1180 4430 -1180 { lab=#net1}
N 4530 -1180 4560 -1180 { lab=#net2}
N 4560 -1210 4560 -1180 { lab=#net2}
N 4620 -1170 4620 -1080 { lab=#net3}
N 960 -1220 1280 -1220 { lab=Qout-pre-buffer}
N 1280 -1220 1600 -1220 { lab=Qout-pre-buffer}
N 1600 -1220 1920 -1220 { lab=Qout-pre-buffer}
N 3880 -1220 3960 -1220 { lab=Qout}
N 3710 -1220 3780 -1220 { lab=#net1}
N 3530 -1220 3610 -1220 { lab=Qout-pre-buffer}
N 3300 -1220 3530 -1220 { lab=Qout-pre-buffer}
N 890 -730 890 -680 { lab=Q0}
N 1120 -730 1120 -680 { lab=Q1}
N 1360 -730 1360 -680 { lab=Q2}
N 460 -680 730 -680 { lab=Q15}
N 700 -630 730 -630 { lab=nQ15}
N 790 -590 790 -470 { lab=CLK}
N 820 -680 950 -680 { lab=Q0}
N 820 -630 950 -630 { lab=#net2}
N 1040 -680 1180 -680 { lab=Q1}
N 1270 -680 1420 -680 { lab=Q2}
N 1040 -630 1180 -630 { lab=#net3}
N 1270 -630 1420 -630 { lab=#net4}
N 1010 -590 1010 -470 { lab=CLK}
N 1240 -590 1240 -470 { lab=CLK}
N 1480 -590 1480 -470 { lab=CLK}
N 980 -740 980 -710 { lab=VDD}
N 1210 -740 1210 -710 { lab=VDD}
N 1450 -740 1450 -710 { lab=VDD}
N 1600 -730 1600 -680 { lab=Q3}
N 1510 -680 1660 -680 { lab=Q3}
N 1510 -630 1660 -630 { lab=#net5}
N 1720 -590 1720 -470 { lab=CLK}
N 1690 -740 1690 -710 { lab=VDD}
N 1840 -730 1840 -680 { lab=Q4}
N 1750 -680 1900 -680 { lab=Q4}
N 1750 -630 1900 -630 { lab=#net6}
N 1960 -590 1960 -470 { lab=CLK}
N 1930 -740 1930 -710 { lab=VDD}
N 2080 -730 2080 -680 { lab=Q5}
N 1990 -680 2140 -680 { lab=Q5}
N 1990 -630 2140 -630 { lab=#net7}
N 2200 -590 2200 -470 { lab=CLK}
N 2170 -740 2170 -710 { lab=VDD}
N 2320 -730 2320 -680 { lab=Q6}
N 2230 -680 2380 -680 { lab=Q6}
N 2230 -630 2380 -630 { lab=#net8}
N 2410 -740 2410 -710 { lab=VDD}
N 600 -470 2440 -470 { lab=CLK}
N 2560 -730 2560 -680 { lab=Q7}
N 2470 -680 2620 -680 { lab=Q7}
N 2470 -630 2620 -630 { lab=#net9}
N 2650 -740 2650 -710 { lab=VDD}
N 2800 -730 2800 -680 { lab=Q8}
N 2710 -680 2860 -680 { lab=Q8}
N 2710 -630 2860 -630 { lab=#net10}
N 2890 -740 2890 -710 { lab=VDD}
N 3040 -730 3040 -680 { lab=Q9}
N 2950 -680 3100 -680 { lab=Q9}
N 2950 -630 3100 -630 { lab=#net11}
N 3130 -740 3130 -710 { lab=VDD}
N 3280 -730 3280 -680 { lab=Q10}
N 3190 -680 3340 -680 { lab=Q10}
N 3190 -630 3340 -630 { lab=#net12}
N 3370 -740 3370 -710 { lab=VDD}
N 3520 -730 3520 -680 { lab=Q11}
N 3430 -680 3580 -680 { lab=Q11}
N 3430 -630 3580 -630 { lab=#net13}
N 3610 -740 3610 -710 { lab=VDD}
N 3760 -730 3760 -680 { lab=Q12}
N 3670 -680 3820 -680 { lab=Q12}
N 3670 -630 3820 -630 { lab=#net14}
N 3850 -740 3850 -710 { lab=VDD}
N 4000 -730 4000 -680 { lab=Q13}
N 3910 -680 4060 -680 { lab=Q13}
N 3910 -630 4060 -630 { lab=#net15}
N 4090 -740 4090 -710 { lab=VDD}
N 4240 -730 4240 -680 { lab=Q14}
N 4150 -680 4300 -680 { lab=Q14}
N 4150 -630 4300 -630 { lab=#net16}
N 4330 -740 4330 -710 { lab=VDD}
N 4480 -730 4480 -680 { lab=Q15}
N 4390 -680 4540 -680 { lab=Q15}
N 2440 -590 2440 -470 { lab=CLK}
N 2680 -590 2680 -470 { lab=CLK}
N 2920 -590 2920 -470 { lab=CLK}
N 3160 -590 3160 -470 { lab=CLK}
N 3400 -590 3400 -470 { lab=CLK}
N 3640 -590 3640 -470 { lab=CLK}
N 3880 -590 3880 -470 { lab=CLK}
N 4120 -590 4120 -470 { lab=CLK}
N 4360 -590 4360 -470 { lab=CLK}
N 2440 -470 4360 -470 { lab=CLK}
N 4390 -630 4540 -630 { lab=nQ15}
N 4630 -630 4700 -630 { lab=nQ15}
N 4700 -630 4700 -420 { lab=nQ15}
N 430 -420 4700 -420 { lab=nQ15}
N 430 -630 700 -630 { lab=nQ15}
N 430 -630 430 -420 { lab=nQ15}
N 4630 -680 4700 -680 { lab=Q15}
N 4700 -830 4700 -680 { lab=Q15}
N 430 -680 460 -680 { lab=Q15}
N 430 -830 4700 -830 { lab=Q15}
N 430 -830 430 -680 { lab=Q15}
N 4540 -680 4630 -680 { lab=Q15}
N 4540 -630 4630 -630 { lab=nQ15}
N 4480 -630 4480 -600 { lab=nQ15}
N 850 -1220 850 -1210 { lab=Qout-pre-buffer}
N 640 -1220 640 -1210 { lab=Qout-pre-buffer}
N 640 -1220 960 -1220 { lab=Qout-pre-buffer}
N 1250 -1220 1250 -1210 { lab=Qout-pre-buffer}
N 1040 -1220 1040 -1210 { lab=Qout-pre-buffer}
N 1660 -1220 1660 -1210 { lab=Qout-pre-buffer}
N 1450 -1220 1450 -1210 { lab=Qout-pre-buffer}
N 1850 -1220 1850 -1210 { lab=Qout-pre-buffer}
N 1860 -1300 1930 -1300 { lab=#net17}
N 1960 -1270 1960 -1220 { lab=Qout-pre-buffer}
N 2340 -1220 2660 -1220 { lab=Qout-pre-buffer}
N 2660 -1220 2980 -1220 { lab=Qout-pre-buffer}
N 2980 -1220 3300 -1220 { lab=Qout-pre-buffer}
N 2230 -1220 2230 -1210 { lab=Qout-pre-buffer}
N 2020 -1220 2020 -1210 { lab=Qout-pre-buffer}
N 2020 -1220 2340 -1220 { lab=Qout-pre-buffer}
N 2630 -1220 2630 -1210 { lab=Qout-pre-buffer}
N 2420 -1220 2420 -1210 { lab=Qout-pre-buffer}
N 3040 -1220 3040 -1210 { lab=Qout-pre-buffer}
N 2830 -1220 2830 -1210 { lab=Qout-pre-buffer}
N 3230 -1220 3230 -1210 { lab=Qout-pre-buffer}
N 1920 -1220 2020 -1220 { lab=Qout-pre-buffer}
N 3200 -1300 3270 -1300 { lab=#net18}
N 3300 -1270 3300 -1220 { lab=Qout-pre-buffer}
C {madvlsi/vsource.sym} 290 -280 0 0 {name=Vdd
value=1.8}
C {madvlsi/vsource.sym} 360 -280 0 0 {name=V1
value=1.2}
C {madvlsi/gnd.sym} 290 -250 0 0 {name=l23 lab=GND}
C {madvlsi/gnd.sym} 360 -250 0 0 {name=l24 lab=GND}
C {madvlsi/vdd.sym} 290 -310 0 0 {name=l26 lab=VDD}
C {devices/lab_pin.sym} 360 -310 1 0 {name=l27 sig_type=std_logic lab=Voutp}
C {madvlsi/vsource.sym} 440 -280 0 0 {name=V2
value=0.8}
C {madvlsi/gnd.sym} 440 -250 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} 440 -310 1 0 {name=l2 sig_type=std_logic lab=Voutn}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 4510 -1230 0 0 {name=X2}
C {madvlsi/vdd.sym} 4590 -1290 0 0 {name=l3 lab=VDD}
C {madvlsi/gnd.sym} 4590 -1170 0 0 {name=l4 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/diff_amp.sym} 4180 -1260 0 0 {name=X1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 4470 -1180 0 0 {name=X3 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 4470 -1220 0 0 {name=l5 lab=VDD}
C {madvlsi/gnd.sym} 4470 -1140 0 0 {name=l6 lab=GND}
C {madvlsi/vdd.sym} 4290 -1360 0 0 {name=l7 lab=VDD}
C {madvlsi/gnd.sym} 4290 -1160 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} 4210 -1290 0 0 {name=l9 sig_type=std_logic lab=Voutp}
C {devices/lab_pin.sym} 4210 -1230 0 0 {name=l10 sig_type=std_logic lab=Voutn}
C {devices/lab_pin.sym} 4650 -1260 2 0 {name=l11 sig_type=std_logic lab=Vout}
C {madvlsi/vsource.sym} 200 -440 0 0 {name=VCLK
value="pulse(0 1.8 1u 1n 1n 5u 10u)"}
C {madvlsi/vsource.sym} 200 -280 0 0 {name=Vdd1
value=1.8}
C {madvlsi/gnd.sym} 200 -410 0 0 {name=l22 lab=GND}
C {madvlsi/gnd.sym} 200 -250 0 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} 200 -470 0 0 {name=l25 sig_type=std_logic lab=CLK}
C {madvlsi/vdd.sym} 200 -310 0 0 {name=l13 lab=VDD}
C {madvlsi/tt_models.sym} 520 -320 0 0 {
name=TT_MODELS
only_toplevel=false
value=".option wnflag=1
.param MC_SWITCH=0.0
.lib ~/skywater/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/sky130.lib.spice tt"
}
C {devices/lab_pin.sym} 3960 -1220 1 0 {name=l95 sig_type=std_logic lab=Qout}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3650 -1220 0 0 {name=X27 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3820 -1220 0 0 {name=X28 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} 3650 -1180 0 0 {name=l111 lab=GND}
C {madvlsi/vdd.sym} 3650 -1260 0 0 {name=l112 lab=VDD}
C {madvlsi/gnd.sym} 3820 -1180 0 0 {name=l113 lab=GND}
C {madvlsi/vdd.sym} 3820 -1260 0 0 {name=l114 lab=VDD}
C {devices/lab_pin.sym} 3530 -1220 1 0 {name=l115 sig_type=std_logic lab=Qout-pre-buffer}
C {madvlsi/gnd.sym} 760 -590 0 0 {name=l14 lab=GND}
C {madvlsi/gnd.sym} 980 -590 0 0 {name=l15 lab=GND}
C {madvlsi/gnd.sym} 1210 -590 0 0 {name=l16 lab=GND}
C {madvlsi/gnd.sym} 1450 -590 0 0 {name=l17 lab=GND}
C {madvlsi/vdd.sym} 760 -710 0 0 {name=l18 lab=VDD}
C {madvlsi/vdd.sym} 980 -740 0 0 {name=l19 lab=VDD}
C {madvlsi/vdd.sym} 1210 -740 0 0 {name=l20 lab=VDD}
C {madvlsi/vdd.sym} 1450 -740 0 0 {name=l21 lab=VDD}
C {devices/lab_pin.sym} 600 -470 0 0 {name=l28 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 890 -730 1 0 {name=l31 sig_type=std_logic lab=Q0}
C {devices/lab_pin.sym} 1120 -730 1 0 {name=l32 sig_type=std_logic lab=Q1}
C {devices/lab_pin.sym} 1360 -730 1 0 {name=l33 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 1600 -730 1 0 {name=l34 sig_type=std_logic lab=Q3}
C {devices/code_shown.sym} 4730 -790 0 0 {name=SPICE only_toplevel=false value=".ic v(Q0)=0  v(X2.Qi)=1.8
.ic v(Q1)=0 v(X3.Qi)=1.8
.ic v(Q2)=0 v(X4.Qi)=1.8
.ic v(Q3)=0 v(X5.Qi)=1.8
.ic v(Q4)=0 v(X6.Qi)=1.8
.ic v(Q5)=0 v(X7.Qi)=1.8
.ic v(Q6)=0 v(X8.Qi)=1.8
.ic v(Q7)=0 v(X9.Qi)=1.8
.ic v(Q8)=0 v(X10.Qi)=1.8
.ic v(Q9)=0 v(X11.Qi)=1.8
.ic v(Q10)=0 v(X12.Qi)=1.8
.ic v(Q11)=0 v(X13.Qi)=1.8
.ic v(Q12)=0 v(X14.Qi)=1.8
.ic v(Q13)=0 v(X15.Qi)=1.8
.ic v(Q14)=0 v(X16.Qi)=1.8
.ic v(Q15)=1.8 v(X17.Qi)=0 v(nQ15)=0
.tran 10u 1m
.save all"}
C {devices/lab_pin.sym} 600 -470 0 0 {name=l35 sig_type=std_logic lab=CLK}
C {madvlsi/gnd.sym} 1690 -590 0 0 {name=l36 lab=GND}
C {madvlsi/vdd.sym} 1690 -740 0 0 {name=l37 lab=VDD}
C {madvlsi/gnd.sym} 1930 -590 0 0 {name=l38 lab=GND}
C {madvlsi/vdd.sym} 1930 -740 0 0 {name=l39 lab=VDD}
C {devices/lab_pin.sym} 1840 -730 1 0 {name=l40 sig_type=std_logic lab=Q4}
C {madvlsi/gnd.sym} 2170 -590 0 0 {name=l41 lab=GND}
C {madvlsi/vdd.sym} 2170 -740 0 0 {name=l42 lab=VDD}
C {devices/lab_pin.sym} 2080 -730 1 0 {name=l43 sig_type=std_logic lab=Q5}
C {madvlsi/gnd.sym} 2410 -590 0 0 {name=l44 lab=GND}
C {madvlsi/vdd.sym} 2410 -740 0 0 {name=l45 lab=VDD}
C {devices/lab_pin.sym} 2320 -730 1 0 {name=l46 sig_type=std_logic lab=Q6}
C {madvlsi/gnd.sym} 2650 -590 0 0 {name=l47 lab=GND}
C {madvlsi/vdd.sym} 2650 -740 0 0 {name=l48 lab=VDD}
C {devices/lab_pin.sym} 2560 -730 1 0 {name=l49 sig_type=std_logic lab=Q7}
C {madvlsi/gnd.sym} 2890 -590 0 0 {name=l50 lab=GND}
C {madvlsi/vdd.sym} 2890 -740 0 0 {name=l51 lab=VDD}
C {devices/lab_pin.sym} 2800 -730 1 0 {name=l52 sig_type=std_logic lab=Q8}
C {madvlsi/gnd.sym} 3130 -590 0 0 {name=l53 lab=GND}
C {madvlsi/vdd.sym} 3130 -740 0 0 {name=l54 lab=VDD}
C {devices/lab_pin.sym} 3040 -730 1 0 {name=l55 sig_type=std_logic lab=Q9}
C {madvlsi/gnd.sym} 3370 -590 0 0 {name=l56 lab=GND}
C {madvlsi/vdd.sym} 3370 -740 0 0 {name=l57 lab=VDD}
C {devices/lab_pin.sym} 3280 -730 1 0 {name=l58 sig_type=std_logic lab=Q10}
C {madvlsi/gnd.sym} 3610 -590 0 0 {name=l59 lab=GND}
C {madvlsi/vdd.sym} 3610 -740 0 0 {name=l60 lab=VDD}
C {devices/lab_pin.sym} 3520 -730 1 0 {name=l61 sig_type=std_logic lab=Q11}
C {madvlsi/gnd.sym} 3850 -590 0 0 {name=l62 lab=GND}
C {madvlsi/vdd.sym} 3850 -740 0 0 {name=l63 lab=VDD}
C {devices/lab_pin.sym} 3760 -730 1 0 {name=l64 sig_type=std_logic lab=Q12}
C {madvlsi/gnd.sym} 4090 -590 0 0 {name=l66 lab=GND}
C {madvlsi/vdd.sym} 4090 -740 0 0 {name=l67 lab=VDD}
C {devices/lab_pin.sym} 4000 -730 1 0 {name=l68 sig_type=std_logic lab=Q13}
C {madvlsi/gnd.sym} 4330 -590 0 0 {name=l70 lab=GND}
C {madvlsi/vdd.sym} 4330 -740 0 0 {name=l71 lab=VDD}
C {devices/lab_pin.sym} 4240 -730 1 0 {name=l72 sig_type=std_logic lab=Q14}
C {devices/lab_pin.sym} 4480 -730 1 0 {name=l76 sig_type=std_logic lab=Q15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 680 -650 0 0 {name=X4}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 900 -650 0 0 {name=X5}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 1130 -650 0 0 {name=X6}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 1370 -650 0 0 {name=X7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 1610 -650 0 0 {name=X8}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 1850 -650 0 0 {name=X9}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 2090 -650 0 0 {name=X10}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 2330 -650 0 0 {name=X11}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 2570 -650 0 0 {name=X12}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 2810 -650 0 0 {name=X13}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 3050 -650 0 0 {name=X14}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 3290 -650 0 0 {name=X15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 3530 -650 0 0 {name=X16}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 3770 -650 0 0 {name=X17}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 4010 -650 0 0 {name=X18}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 4250 -650 0 0 {name=X19}
C {devices/lab_pin.sym} 4480 -600 3 0 {name=l65 sig_type=std_logic lab=nQ15}
C {madvlsi/nmos3.sym} 640 -1180 0 0 {name=M1
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 640 -1150 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} 610 -1180 0 0 {name=l73 sig_type=std_logic lab=Q0}
C {madvlsi/nmos3.sym} 850 -1180 0 0 {name=M2
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 850 -1150 0 0 {name=l74 lab=GND}
C {devices/lab_pin.sym} 820 -1180 0 0 {name=l75 sig_type=std_logic lab=Q1}
C {madvlsi/nmos3.sym} 1040 -1180 0 0 {name=M5
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1040 -1150 0 0 {name=l77 lab=GND}
C {devices/lab_pin.sym} 1010 -1180 0 0 {name=l78 sig_type=std_logic lab=Q2}
C {madvlsi/nmos3.sym} 1250 -1180 0 0 {name=M7
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1250 -1150 0 0 {name=l79 lab=GND}
C {devices/lab_pin.sym} 1220 -1180 0 0 {name=l80 sig_type=std_logic lab=Q3}
C {madvlsi/nmos3.sym} 1450 -1180 0 0 {name=M9
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1450 -1150 0 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} 1420 -1180 0 0 {name=l82 sig_type=std_logic lab=Q4}
C {madvlsi/nmos3.sym} 1660 -1180 0 0 {name=M11
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1660 -1150 0 0 {name=l83 lab=GND}
C {devices/lab_pin.sym} 1630 -1180 0 0 {name=l84 sig_type=std_logic lab=Q5}
C {madvlsi/nmos3.sym} 1850 -1180 0 0 {name=M13
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1850 -1150 0 0 {name=l85 lab=GND}
C {devices/lab_pin.sym} 1820 -1180 0 0 {name=l86 sig_type=std_logic lab=Q6}
C {madvlsi/pmos3.sym} 1960 -1300 0 0 {name=M14
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1800 -1300 0 0 {name=X20 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} 1800 -1260 0 0 {name=l87 lab=GND}
C {madvlsi/vdd.sym} 1800 -1340 0 0 {name=l88 lab=VDD}
C {madvlsi/vdd.sym} 1960 -1330 0 0 {name=l89 lab=VDD}
C {devices/lab_pin.sym} 1760 -1300 0 0 {name=l90 sig_type=std_logic lab=Q7}
C {madvlsi/nmos3.sym} 2020 -1180 0 0 {name=M3
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2020 -1150 0 0 {name=l91 lab=GND}
C {devices/lab_pin.sym} 1990 -1180 0 0 {name=l92 sig_type=std_logic lab=Q8}
C {madvlsi/nmos3.sym} 2230 -1180 0 0 {name=M4
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2230 -1150 0 0 {name=l93 lab=GND}
C {devices/lab_pin.sym} 2200 -1180 0 0 {name=l94 sig_type=std_logic lab=Q9}
C {madvlsi/nmos3.sym} 2420 -1180 0 0 {name=M6
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2420 -1150 0 0 {name=l96 lab=GND}
C {devices/lab_pin.sym} 2390 -1180 0 0 {name=l97 sig_type=std_logic lab=Q10}
C {madvlsi/nmos3.sym} 2630 -1180 0 0 {name=M8
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2630 -1150 0 0 {name=l98 lab=GND}
C {devices/lab_pin.sym} 2600 -1180 0 0 {name=l99 sig_type=std_logic lab=Q11}
C {madvlsi/nmos3.sym} 2830 -1180 0 0 {name=M10
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2830 -1150 0 0 {name=l100 lab=GND}
C {devices/lab_pin.sym} 2800 -1180 0 0 {name=l101 sig_type=std_logic lab=Q12}
C {madvlsi/nmos3.sym} 3040 -1180 0 0 {name=M12
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 3040 -1150 0 0 {name=l102 lab=GND}
C {devices/lab_pin.sym} 3010 -1180 0 0 {name=l103 sig_type=std_logic lab=Q13}
C {madvlsi/nmos3.sym} 3230 -1180 0 0 {name=M15
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 3230 -1150 0 0 {name=l104 lab=GND}
C {devices/lab_pin.sym} 3200 -1180 0 0 {name=l105 sig_type=std_logic lab=Q14}
C {madvlsi/pmos3.sym} 3300 -1300 0 0 {name=M16
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3140 -1300 0 0 {name=X21 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} 3140 -1260 0 0 {name=l106 lab=GND}
C {madvlsi/vdd.sym} 3140 -1340 0 0 {name=l107 lab=VDD}
C {madvlsi/vdd.sym} 3300 -1330 0 0 {name=l108 lab=VDD}
C {devices/lab_pin.sym} 3100 -1300 0 0 {name=l109 sig_type=std_logic lab=Q15}
C {devices/lab_pin.sym} 4620 -1080 0 0 {name=l110 sig_type=std_logic lab=Qout}
