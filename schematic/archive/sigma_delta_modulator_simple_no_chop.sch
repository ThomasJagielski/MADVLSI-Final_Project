v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 1110 -1180 1110 -620 { lab=#net1}
N 1110 -560 1110 0 { lab=#net2}
N 1110 -1180 1230 -1180 { lab=#net1}
N 1110 -690 1230 -690 { lab=#net1}
N 1110 0 1230 0 { lab=#net2}
N 1420 -780 1570 -780 { lab=#net3}
N 1630 -780 1780 -780 { lab=#net4}
N 1420 -400 1570 -400 { lab=#net5}
N 1630 -400 1780 -400 { lab=#net6}
N 1420 -910 1570 -910 { lab=#net3}
N 1420 -910 1420 -780 { lab=#net3}
N 1630 -910 1780 -910 { lab=#net4}
N 1780 -910 1780 -780 { lab=#net4}
N 1630 -240 1780 -240 { lab=#net6}
N 1420 -420 1420 -240 { lab=#net5}
N 1420 -240 1570 -240 { lab=#net5}
N 1420 -780 1420 -690 { lab=#net3}
N 1420 -480 1420 -420 { lab=#net5}
N 1110 -480 1230 -480 { lab=#net2}
N 2720 -780 2870 -780 { lab=Voutp}
N 2930 -780 3080 -780 { lab=Voutp}
N 3080 -780 3080 -690 { lab=Voutp}
N 2720 -400 2870 -400 { lab=Voutn}
N 2930 -400 3080 -400 { lab=Voutn}
N 2720 -910 2870 -910 { lab=Voutp}
N 2720 -910 2720 -780 { lab=Voutp}
N 2930 -910 3080 -910 { lab=Voutp}
N 3080 -910 3080 -780 { lab=Voutp}
N 2930 -240 3080 -240 { lab=Voutn}
N 2720 -420 2720 -240 { lab=Voutn}
N 2720 -240 2870 -240 { lab=Voutn}
N 2720 -780 2720 -690 { lab=Voutp}
N 2720 -480 2720 -420 { lab=Voutn}
N 1910 170 1940 170 { lab=Vinn}
N 1910 170 1910 270 { lab=Vinn}
N 2000 170 2050 170 { lab=#net7}
N 2110 170 2180 170 { lab=#net8}
N 2180 170 2180 270 { lab=#net8}
N 2110 270 2180 270 { lab=#net8}
N 2180 270 2480 270 { lab=#net8}
N 2400 220 2400 270 { lab=#net8}
N 1980 -240 2050 -240 { lab=#net9}
N 2020 -330 2020 -240 { lab=#net9}
N 2110 -240 2200 -240 { lab=#net10}
N 2150 -320 2150 -240 { lab=#net10}
N 1980 -910 2050 -910 { lab=#net11}
N 2020 -910 2020 -820 { lab=#net11}
N 2110 -910 2200 -910 { lab=#net12}
N 2020 -520 2020 -390 { lab=Vcm}
N 2150 -520 2150 -380 { lab=Vcm}
N 2020 -520 2150 -520 { lab=Vcm}
N 2020 -760 2020 -670 { lab=Vcm}
N 2020 -670 2150 -670 { lab=Vcm}
N 2150 -760 2150 -670 { lab=Vcm}
N 2150 -910 2150 -820 { lab=#net12}
N 1900 -1420 1960 -1420 { lab=Vinp}
N 1900 -1520 1900 -1420 { lab=Vinp}
N 2020 -1420 2080 -1420 { lab=#net13}
N 2140 -1520 2260 -1520 { lab=#net14}
N 2260 -1520 2260 -1420 { lab=#net14}
N 2140 -1420 2260 -1420 { lab=#net14}
N 2360 -1520 2360 -1480 { lab=#net14}
N 2540 -1520 2620 -1520 { lab=Voutp}
N 2540 270 2620 270 { lab=Voutn}
N 2620 -480 2620 270 { lab=Voutn}
N 2260 -240 2620 -240 { lab=Voutn}
N 2620 -1520 2620 -690 { lab=Voutp}
N 2260 -1520 2480 -1520 { lab=#net14}
N 2260 -910 2620 -910 { lab=Voutp}
N 3080 -480 3120 -480 { lab=Voutn}
N 3080 -690 3120 -690 { lab=Voutp}
N 1070 -560 1110 -560 { lab=#net2}
N 1070 -620 1110 -620 { lab=#net1}
N 3120 -690 3120 -610 { lab=Voutp}
N 3120 -570 3120 -480 { lab=Voutn}
N 1420 -640 1550 -640 { lab=#net1}
N 1420 -640 1420 -620 { lab=#net1}
N 1420 -540 1550 -540 { lab=#net2}
N 1420 -560 1420 -540 { lab=#net2}
N 2620 -540 2620 -480 { lab=Voutn}
N 2620 -690 2620 -640 { lab=Voutp}
N 2400 140 2400 160 { lab=Vcm}
N 2360 -1420 2360 -1400 { lab=Vcm}
N 2080 -600 2110 -600 { lab=Vcm}
N 1110 -620 1420 -620 { lab=#net1}
N 1110 -560 1420 -560 { lab=#net2}
N 1290 -690 1420 -690 { lab=#net3}
N 1290 -480 1420 -480 { lab=#net5}
N 1780 -400 1780 -240 { lab=#net6}
N 1780 -570 1780 -400 { lab=#net6}
N 1780 -780 1780 -610 { lab=#net4}
N 880 -560 880 270 { lab=Vinn}
N 880 -1520 880 -620 { lab=Vinp}
N 800 -560 1010 -560 { lab=Vinn}
N 800 -620 1010 -620 { lab=Vinp}
N 1290 -1180 1780 -1180 { lab=#net4}
N 1780 -1180 1780 -910 { lab=#net4}
N 1290 -0 1780 -0 { lab=#net6}
N 1780 -240 1780 -0 { lab=#net6}
N 2620 -690 3080 -690 { lab=Voutp}
N 2620 -480 3080 -480 { lab=Voutn}
N 3080 -400 3080 -240 { lab=Voutn}
N 3080 -480 3080 -400 { lab=Voutn}
N 2620 -640 2860 -640 { lab=Voutp}
N 2620 -540 2860 -540 { lab=Voutn}
N 2080 -670 2080 -520 { lab=Vcm}
N 880 -1520 2080 -1520 { lab=Vinp}
N 880 270 2050 270 { lab=Vinn}
N 1680 -610 1780 -610 { lab=#net4}
N 1680 -570 1780 -570 { lab=#net6}
N 1780 -240 1920 -240 { lab=#net6}
N 1780 -910 1920 -910 { lab=#net4}
N 2990 -610 3160 -610 { lab=Voutp}
N 2990 -570 3160 -570 { lab=Voutn}
N -840 -910 -590 -910 { lab=#net15}
N -840 -1000 -840 -910 { lab=#net15}
N -960 -1200 -590 -1200 { lab=Vphi1gen}
N -840 -1200 -840 -1100 { lab=Vphi1gen}
N -410 -940 -340 -940 { lab=#net16}
N -410 -1170 -340 -1170 { lab=#net17}
N -240 -1170 -200 -1170 { lab=#net18}
N -100 -1170 -60 -1170 { lab=#net19}
N -240 -940 -200 -940 { lab=#net20}
N -100 -940 -60 -940 { lab=#net21}
N -620 -1140 -590 -1140 { lab=#net21}
N -620 -1140 -620 -1080 { lab=#net21}
N -620 -1080 -60 -1080 { lab=#net21}
N -60 -1080 -60 -940 { lab=#net21}
N -100 -1170 -100 -1030 { lab=#net19}
N -620 -1030 -100 -1030 { lab=#net19}
N -620 -1030 -620 -970 { lab=#net19}
N -620 -970 -590 -970 { lab=#net19}
N 40 -1170 80 -1170 { lab=Vphi1}
N 40 -940 80 -940 { lab=Vphi2}
N 60 -850 130 -850 { lab=Vphi2}
N 60 -940 60 -850 { lab=Vphi2}
N 60 -1090 130 -1090 { lab=Vphi1}
N 60 -1170 60 -1090 { lab=Vphi1}
N -840 -1440 -590 -1440 { lab=#net22}
N -840 -1530 -840 -1440 { lab=#net22}
N -960 -1730 -590 -1730 { lab=VphiF1gen}
N -840 -1730 -840 -1630 { lab=VphiF1gen}
N -410 -1470 -340 -1470 { lab=#net23}
N -410 -1700 -340 -1700 { lab=#net24}
N -240 -1700 -200 -1700 { lab=#net25}
N -100 -1700 -60 -1700 { lab=#net26}
N -240 -1470 -200 -1470 { lab=#net27}
N -100 -1470 -60 -1470 { lab=#net28}
N -620 -1670 -590 -1670 { lab=#net28}
N -620 -1670 -620 -1610 { lab=#net28}
N -620 -1610 -60 -1610 { lab=#net28}
N -60 -1610 -60 -1470 { lab=#net28}
N -100 -1700 -100 -1560 { lab=#net26}
N -620 -1560 -100 -1560 { lab=#net26}
N -620 -1560 -620 -1500 { lab=#net26}
N -620 -1500 -590 -1500 { lab=#net26}
N 40 -1700 80 -1700 { lab=Vf1}
N 40 -1470 80 -1470 { lab=Vf2}
N 60 -1380 130 -1380 { lab=Vf2}
N 60 -1470 60 -1380 { lab=Vf2}
N 60 -1620 130 -1620 { lab=Vf1}
N 60 -1700 60 -1620 { lab=Vf1}
N -270 -750 -270 -720 { lab=Vbp}
N -270 -720 -240 -720 { lab=Vbp}
N -270 -750 -160 -750 { lab=Vbp}
N -160 -720 -160 -690 { lab=Vbn}
N -160 -720 -130 -720 { lab=Vbn}
N 230 -1380 250 -1380 { lab=Vnf2}
N 230 -1620 250 -1620 { lab=Vnf1}
C {madvlsi/capacitor.sym} 1040 -620 1 0 {name=C8
value=1p
m=1}
C {madvlsi/capacitor.sym} 1040 -560 1 0 {name=C9
value=1p
m=1}
C {madvlsi/capacitor.sym} 1600 -780 1 0 {name=C17
value=1p
m=1}
C {madvlsi/capacitor.sym} 1600 -400 1 0 {name=C18
value=1p
m=1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1260 -690 0 0 {name=X23 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1260 -480 0 0 {name=X24 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1260 -1180 0 0 {name=X25 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1260 0 0 0 {name=X26 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1600 -910 0 0 {name=X27 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1600 -240 0 0 {name=X28 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1950 -910 0 0 {name=X3 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1950 -240 0 0 {name=X21 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2230 -910 0 0 {name=X29 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2230 -240 0 0 {name=X30 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/capacitor.sym} 2900 -780 1 0 {name=C19
value=1p
m=1}
C {madvlsi/capacitor.sym} 2900 -400 1 0 {name=C20
value=1p
m=1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2900 -910 0 0 {name=X34 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2900 -240 0 0 {name=X35 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/capacitor.sym} 2080 -910 1 0 {name=C21
value=2p
m=1}
C {madvlsi/capacitor.sym} 2080 -240 1 0 {name=C22
value=2p
m=1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2020 -360 1 0 {name=X36 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2150 -350 3 0 {name=X37 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2020 -790 1 0 {name=X38 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2150 -790 3 0 {name=X39 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/capacitor.sym} 2110 -1520 1 0 {name=C23
value=1p
m=1}
C {madvlsi/capacitor.sym} 2110 -1420 1 0 {name=C24
value=1p
m=7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1990 -1420 0 0 {name=X40 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2360 -1450 1 0 {name=X41 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2510 -1520 0 0 {name=X42 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/capacitor.sym} 2080 170 1 0 {name=C25
value=1p
m=7}
C {madvlsi/capacitor.sym} 2080 270 1 0 {name=C26
value=1p
m=1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1970 170 0 0 {name=X43 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2510 270 0 0 {name=X44 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2400 190 1 0 {name=X45 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/fully_differential_sc_amp.sym} 1660 -630 0 0 {name=X2 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/fully_differential_sc_amp.sym} 2970 -630 0 0 {name=X31 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {devices/lab_pin.sym} 1250 -670 3 0 {name=l3 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 1270 -670 3 0 {name=l4 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 1250 -460 3 0 {name=l5 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 1270 -460 3 0 {name=l6 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 1250 -1160 3 0 {name=l7 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 1270 -1160 3 0 {name=l8 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 1250 20 3 0 {name=l9 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 1270 20 3 0 {name=l10 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 1590 -890 3 0 {name=l11 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 1610 -890 3 0 {name=l12 sig_type=std_logic lab=nreset}
C {devices/lab_pin.sym} 1590 -220 3 0 {name=l13 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 1610 -220 3 0 {name=l14 sig_type=std_logic lab=nreset}
C {devices/lab_pin.sym} 1940 -890 3 0 {name=l1 sig_type=std_logic lab=Vf2}
C {devices/lab_pin.sym} 1960 -890 3 0 {name=l2 sig_type=std_logic lab=Vnf2}
C {devices/lab_pin.sym} 1980 -1400 3 0 {name=l15 sig_type=std_logic lab=nbs}
C {devices/lab_pin.sym} 2000 -1400 3 0 {name=l16 sig_type=std_logic lab=bs}
C {devices/lab_pin.sym} 1960 190 3 0 {name=l17 sig_type=std_logic lab=nbs}
C {devices/lab_pin.sym} 1980 190 3 0 {name=l18 sig_type=std_logic lab=bs}
C {devices/lab_pin.sym} 2400 140 1 0 {name=l19 sig_type=std_logic lab=Vcm}
C {devices/lab_pin.sym} 2360 -1400 3 0 {name=l20 sig_type=std_logic lab=Vcm}
C {devices/lab_pin.sym} 2380 180 0 0 {name=l21 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 2380 200 0 0 {name=l22 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 2340 -1460 0 0 {name=l23 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 2340 -1440 0 0 {name=l24 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 2500 290 3 0 {name=l25 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 2520 290 3 0 {name=l26 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 2500 -1500 3 0 {name=l27 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 2520 -1500 3 0 {name=l28 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 2110 -600 2 0 {name=l29 sig_type=std_logic lab=Vcm}
C {devices/lab_pin.sym} 1940 -220 3 0 {name=l30 sig_type=std_logic lab=Vf2}
C {devices/lab_pin.sym} 1960 -220 3 0 {name=l31 sig_type=std_logic lab=Vnf2}
C {devices/lab_pin.sym} 2220 -220 3 0 {name=l32 sig_type=std_logic lab=Vf1}
C {devices/lab_pin.sym} 2240 -220 3 0 {name=l33 sig_type=std_logic lab=Vnf1}
C {devices/lab_pin.sym} 2000 -800 0 0 {name=l34 sig_type=std_logic lab=Vf1}
C {devices/lab_pin.sym} 2000 -780 0 0 {name=l35 sig_type=std_logic lab=Vnf1}
C {devices/lab_pin.sym} 2220 -890 3 0 {name=l36 sig_type=std_logic lab=Vf1}
C {devices/lab_pin.sym} 2240 -890 3 0 {name=l37 sig_type=std_logic lab=Vnf1}
C {devices/lab_pin.sym} 2000 -370 0 0 {name=l38 sig_type=std_logic lab=Vf1}
C {devices/lab_pin.sym} 2000 -350 0 0 {name=l39 sig_type=std_logic lab=Vnf1}
C {devices/lab_pin.sym} 2170 -800 2 0 {name=l40 sig_type=std_logic lab=Vf2}
C {devices/lab_pin.sym} 2170 -780 2 0 {name=l41 sig_type=std_logic lab=Vnf2}
C {devices/lab_pin.sym} 2170 -360 2 0 {name=l42 sig_type=std_logic lab=Vf2}
C {devices/lab_pin.sym} 2170 -340 2 0 {name=l43 sig_type=std_logic lab=Vnf2}
C {devices/lab_pin.sym} 2890 -890 3 0 {name=l44 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 2910 -890 3 0 {name=l45 sig_type=std_logic lab=nreset}
C {devices/lab_pin.sym} 2890 -220 3 0 {name=l46 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 2910 -220 3 0 {name=l47 sig_type=std_logic lab=nreset}
C {devices/lab_pin.sym} 1550 -610 0 0 {name=l48 sig_type=std_logic lab=Vbp}
C {devices/lab_pin.sym} 1550 -590 0 0 {name=l49 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 1550 -570 0 0 {name=l50 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} 2860 -610 0 0 {name=l51 sig_type=std_logic lab=Vbp}
C {devices/lab_pin.sym} 2860 -590 0 0 {name=l52 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 2860 -570 0 0 {name=l53 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} 800 -620 0 0 {name=l54 sig_type=std_logic lab=Vinp}
C {devices/lab_pin.sym} 800 -560 0 0 {name=l55 sig_type=std_logic lab=Vinn}
C {devices/lab_pin.sym} 3160 -610 2 0 {name=l56 sig_type=std_logic lab=Voutp}
C {devices/lab_pin.sym} 3160 -570 2 0 {name=l57 sig_type=std_logic lab=Voutn}
C {madvlsi/vsource.sym} 800 -590 0 0 {name=Vin
value=1}
C {madvlsi/vsource.sym} -480 -680 0 0 {name=Vdd
value=1.8}
C {madvlsi/gnd.sym} -480 -650 0 0 {name=l59 lab=GND}
C {madvlsi/vdd.sym} -480 -710 0 0 {name=l61 lab=VDD}
C {madvlsi/tt_models.sym} 40 -360 0 0 {
name=TT_MODELS
only_toplevel=false
value=".option wnflag=1
.param MC_SWITCH=0.0
.lib ~/skywater/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/sky130.lib.spice tt"
}
C {madvlsi/vsource.sym} -480 -310 0 0 {name=VphiF1
value="PWL(0u 1.8 +5.9u 1.8 +6.1u 0 +7.9 0 +8.1 1.8 +13.9 1.8 +14.9 0 +16 0)"}
C {madvlsi/gnd.sym} -480 -280 0 0 {name=l58 lab=GND}
C {devices/lab_pin.sym} -480 -340 1 0 {name=l60 sig_type=std_logic lab=VphiF1gen}
C {madvlsi/vsource.sym} -440 -130 0 0 {name=Vphi1
value="PWL(0u 1.8 +1.9u 1.8 +2.1u 0 +3.9u 0 +4.1u 1.8 +5.9u 1.8 +6.1u 0 +7.9u 0 +8.1u 1.8 +11.9u 1.8 +12.1u 0 +16u 0)"}
C {madvlsi/gnd.sym} -440 -100 0 0 {name=l74 lab=GND}
C {devices/lab_pin.sym} -440 -160 1 0 {name=l75 sig_type=std_logic lab=Vphi1gen}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/nor2.sym} -510 -1170 0 0 {name=X1 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/nor2.sym} -510 -940 0 0 {name=X4 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -300 -1170 0 0 {name=X5}
C {madvlsi/vdd.sym} -300 -1210 0 0 {name=l68 lab=VDD}
C {madvlsi/gnd.sym} -300 -1130 0 0 {name=l69 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -300 -940 0 0 {name=X6}
C {madvlsi/vdd.sym} -300 -980 0 0 {name=l78 lab=VDD}
C {madvlsi/gnd.sym} -300 -900 0 0 {name=l79 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -160 -1170 0 0 {name=X7}
C {madvlsi/vdd.sym} -160 -1210 0 0 {name=l80 lab=VDD}
C {madvlsi/gnd.sym} -160 -1130 0 0 {name=l81 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -160 -940 0 0 {name=X10}
C {madvlsi/vdd.sym} -160 -980 0 0 {name=l82 lab=VDD}
C {madvlsi/gnd.sym} -160 -900 0 0 {name=l83 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -20 -1170 0 0 {name=X11}
C {madvlsi/vdd.sym} -20 -1210 0 0 {name=l84 lab=VDD}
C {madvlsi/gnd.sym} -20 -1130 0 0 {name=l85 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -20 -940 0 0 {name=X12}
C {madvlsi/vdd.sym} -20 -980 0 0 {name=l86 lab=VDD}
C {madvlsi/gnd.sym} -20 -900 0 0 {name=l87 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -840 -1060 1 0 {name=X13}
C {madvlsi/vdd.sym} -800 -1060 1 0 {name=l88 lab=VDD}
C {madvlsi/gnd.sym} -880 -1060 1 0 {name=l89 lab=GND}
C {devices/lab_pin.sym} -960 -1200 0 0 {name=l90 sig_type=std_logic lab=Vphi1gen}
C {devices/lab_pin.sym} 80 -1170 2 0 {name=l62 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 80 -940 2 0 {name=l63 sig_type=std_logic lab=Vphi2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 170 -1090 0 0 {name=X14}
C {madvlsi/vdd.sym} 170 -1130 0 0 {name=l91 lab=VDD}
C {madvlsi/gnd.sym} 170 -1050 0 0 {name=l92 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 170 -850 0 0 {name=X15}
C {madvlsi/vdd.sym} 170 -890 0 0 {name=l93 lab=VDD}
C {madvlsi/gnd.sym} 170 -810 0 0 {name=l94 lab=GND}
C {devices/lab_pin.sym} 230 -1090 2 0 {name=l95 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 230 -850 2 0 {name=l96 sig_type=std_logic lab=Vnphi2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/nor2.sym} -510 -1700 0 0 {name=X16 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/nor2.sym} -510 -1470 0 0 {name=X17 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -300 -1700 0 0 {name=X18}
C {madvlsi/vdd.sym} -300 -1740 0 0 {name=l97 lab=VDD}
C {madvlsi/gnd.sym} -300 -1660 0 0 {name=l98 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -300 -1470 0 0 {name=X19}
C {madvlsi/vdd.sym} -300 -1510 0 0 {name=l99 lab=VDD}
C {madvlsi/gnd.sym} -300 -1430 0 0 {name=l100 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -160 -1700 0 0 {name=X20}
C {madvlsi/vdd.sym} -160 -1740 0 0 {name=l101 lab=VDD}
C {madvlsi/gnd.sym} -160 -1660 0 0 {name=l102 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -160 -1470 0 0 {name=X22}
C {madvlsi/vdd.sym} -160 -1510 0 0 {name=l103 lab=VDD}
C {madvlsi/gnd.sym} -160 -1430 0 0 {name=l104 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -20 -1700 0 0 {name=X32}
C {madvlsi/vdd.sym} -20 -1740 0 0 {name=l105 lab=VDD}
C {madvlsi/gnd.sym} -20 -1660 0 0 {name=l106 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -20 -1470 0 0 {name=X33}
C {madvlsi/vdd.sym} -20 -1510 0 0 {name=l107 lab=VDD}
C {madvlsi/gnd.sym} -20 -1430 0 0 {name=l108 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -840 -1590 1 0 {name=X46}
C {madvlsi/vdd.sym} -800 -1590 1 0 {name=l109 lab=VDD}
C {madvlsi/gnd.sym} -880 -1590 1 0 {name=l110 lab=GND}
C {devices/lab_pin.sym} 80 -1700 2 0 {name=l112 sig_type=std_logic lab=Vf1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 170 -1620 0 0 {name=X47}
C {madvlsi/vdd.sym} 170 -1660 0 0 {name=l114 lab=VDD}
C {madvlsi/gnd.sym} 170 -1580 0 0 {name=l115 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 170 -1380 0 0 {name=X48}
C {madvlsi/vdd.sym} 170 -1420 0 0 {name=l116 lab=VDD}
C {madvlsi/gnd.sym} 170 -1340 0 0 {name=l117 lab=GND}
C {devices/lab_pin.sym} 250 -1380 2 0 {name=l119 sig_type=std_logic lab=Vnf2}
C {devices/lab_pin.sym} -960 -1730 0 0 {name=l120 sig_type=std_logic lab=VphiF1gen}
C {devices/lab_pin.sym} 250 -1620 2 0 {name=l111 sig_type=std_logic lab=Vnf1}
C {devices/lab_pin.sym} 80 -1470 2 0 {name=l118 sig_type=std_logic lab=Vf2}
C {devices/code_shown.sym} 40 -500 0 0 {name=SPICE only_toplevel=false value=".param WW=6 LL=1 Wp=6 Lp=1
.tran 0.5u 70u
.save all"
}
C {madvlsi/vsource.sym} -380 -680 0 0 {name=Vref
value=0.9}
C {madvlsi/gnd.sym} -380 -650 0 0 {name=l113 lab=GND}
C {devices/lab_pin.sym} -270 -750 1 0 {name=l64 sig_type=std_logic lab=Vbp}
C {madvlsi/pmos3.sym} -240 -750 0 0 {name=M5
L=1
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/isource.sym} -240 -690 0 0 {name=I1
value=1u}
C {madvlsi/vdd.sym} -240 -780 0 0 {name=l65 lab=VDD}
C {madvlsi/gnd.sym} -240 -660 0 0 {name=l66 lab=GND}
C {madvlsi/pmos3.sym} -130 -750 0 0 {name=M1
L=1
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} -130 -780 0 0 {name=l67 lab=VDD}
C {madvlsi/nmos3.sym} -130 -690 0 0 {name=M2
L=LL
W=WW
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -160 -690 0 0 {name=l70 sig_type=std_logic lab=Vbn}
C {madvlsi/gnd.sym} -130 -660 0 0 {name=l71 lab=GND}
C {devices/lab_pin.sym} -380 -710 1 0 {name=l72 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} -370 -480 1 0 {name=l73 sig_type=std_logic lab=reset}
C {madvlsi/vsource.sym} -480 10 0 0 {name=Vphi2
value="PWL(0u 0 +7.9u 0 +8.1u 1.8 +16u 1.8)"}
C {madvlsi/gnd.sym} -480 40 0 0 {name=l122 lab=GND}
C {devices/lab_pin.sym} -480 -20 1 0 {name=l123 sig_type=std_logic lab=bs}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -360 150 0 0 {name=X8}
C {madvlsi/vdd.sym} -360 110 0 0 {name=l124 lab=VDD}
C {madvlsi/gnd.sym} -360 190 0 0 {name=l125 lab=GND}
C {devices/lab_pin.sym} -300 150 2 0 {name=l126 sig_type=std_logic lab=nbs}
C {devices/lab_pin.sym} -400 150 0 0 {name=l127 sig_type=std_logic lab=bs}
C {madvlsi/vsource.sym} -370 -450 0 0 {name=Vreset
value="PWL(0u 0 +16 0)"}
C {madvlsi/gnd.sym} -370 -420 0 0 {name=l76 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -160 -450 0 0 {name=X9}
C {madvlsi/vdd.sym} -160 -490 0 0 {name=l77 lab=VDD}
C {madvlsi/gnd.sym} -160 -410 0 0 {name=l121 lab=GND}
C {devices/lab_pin.sym} -100 -450 2 0 {name=l128 sig_type=std_logic lab=nreset}
C {devices/lab_pin.sym} -200 -450 0 0 {name=l129 sig_type=std_logic lab=reset}
