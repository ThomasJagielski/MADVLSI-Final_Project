v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 1110 -1180 1110 -620 { lab=#net1}
N 1110 -560 1110 0 { lab=#net2}
N 1110 -1180 1230 -1180 { lab=#net1}
N 1110 -690 1230 -690 { lab=#net1}
N 1110 0 1230 0 { lab=#net2}
N 1420 -780 1570 -780 { lab=#net3}
N 1630 -780 1780 -780 { lab=#net4}
N 1420 -400 1570 -400 { lab=#net5}
N 1630 -400 1780 -400 { lab=#net6}
N 1420 -910 1570 -910 { lab=#net3}
N 1420 -910 1420 -780 { lab=#net3}
N 1630 -910 1780 -910 { lab=#net4}
N 1780 -910 1780 -780 { lab=#net4}
N 1630 -240 1780 -240 { lab=#net6}
N 1420 -420 1420 -240 { lab=#net5}
N 1420 -240 1570 -240 { lab=#net5}
N 1420 -780 1420 -690 { lab=#net3}
N 1420 -480 1420 -420 { lab=#net5}
N 1110 -480 1230 -480 { lab=#net2}
N 2720 -780 2870 -780 { lab=Voutp}
N 2930 -780 3080 -780 { lab=Voutp}
N 3080 -780 3080 -690 { lab=Voutp}
N 2720 -400 2870 -400 { lab=Voutn}
N 2930 -400 3080 -400 { lab=Voutn}
N 2720 -910 2870 -910 { lab=Voutp}
N 2720 -910 2720 -780 { lab=Voutp}
N 2930 -910 3080 -910 { lab=Voutp}
N 3080 -910 3080 -780 { lab=Voutp}
N 2930 -240 3080 -240 { lab=Voutn}
N 2720 -420 2720 -240 { lab=Voutn}
N 2720 -240 2870 -240 { lab=Voutn}
N 2720 -780 2720 -690 { lab=Voutp}
N 2720 -480 2720 -420 { lab=Voutn}
N 1910 170 1940 170 { lab=Vinn}
N 1910 170 1910 270 { lab=Vinn}
N 2000 170 2050 170 { lab=#net7}
N 2110 170 2180 170 { lab=#net8}
N 2180 170 2180 270 { lab=#net8}
N 2110 270 2180 270 { lab=#net8}
N 2180 270 2480 270 { lab=#net8}
N 2400 220 2400 270 { lab=#net8}
N 1980 -240 2050 -240 { lab=#net9}
N 2020 -330 2020 -240 { lab=#net9}
N 2110 -240 2200 -240 { lab=#net10}
N 2150 -320 2150 -240 { lab=#net10}
N 1980 -910 2050 -910 { lab=#net11}
N 2020 -910 2020 -820 { lab=#net11}
N 2110 -910 2200 -910 { lab=#net12}
N 2020 -520 2020 -390 { lab=Vcm}
N 2150 -520 2150 -380 { lab=Vcm}
N 2020 -520 2150 -520 { lab=Vcm}
N 2020 -760 2020 -670 { lab=Vcm}
N 2020 -670 2150 -670 { lab=Vcm}
N 2150 -760 2150 -670 { lab=Vcm}
N 2150 -910 2150 -820 { lab=#net12}
N 1900 -1420 1960 -1420 { lab=Vinp}
N 1900 -1520 1900 -1420 { lab=Vinp}
N 2020 -1420 2080 -1420 { lab=#net13}
N 2140 -1520 2260 -1520 { lab=#net14}
N 2260 -1520 2260 -1420 { lab=#net14}
N 2140 -1420 2260 -1420 { lab=#net14}
N 2360 -1520 2360 -1480 { lab=#net14}
N 2540 -1520 2620 -1520 { lab=Voutp}
N 2540 270 2620 270 { lab=Voutn}
N 2620 -480 2620 270 { lab=Voutn}
N 2260 -240 2620 -240 { lab=Voutn}
N 2620 -1520 2620 -690 { lab=Voutp}
N 2260 -1520 2480 -1520 { lab=#net14}
N 2260 -910 2620 -910 { lab=Voutp}
N 3080 -480 3120 -480 { lab=Voutn}
N 3080 -690 3120 -690 { lab=Voutp}
N 1070 -560 1110 -560 { lab=#net2}
N 1070 -620 1110 -620 { lab=#net1}
N 3120 -690 3120 -610 { lab=Voutp}
N 3120 -570 3120 -480 { lab=Voutn}
N 1420 -640 1550 -640 { lab=#net1}
N 1420 -640 1420 -620 { lab=#net1}
N 1420 -540 1550 -540 { lab=#net2}
N 1420 -560 1420 -540 { lab=#net2}
N 2620 -540 2620 -480 { lab=Voutn}
N 2620 -690 2620 -640 { lab=Voutp}
N 2400 140 2400 160 { lab=Vcm}
N 2360 -1420 2360 -1400 { lab=Vcm}
N 2080 -600 2110 -600 { lab=Vcm}
N 1110 -620 1420 -620 { lab=#net1}
N 1110 -560 1420 -560 { lab=#net2}
N 1290 -690 1420 -690 { lab=#net3}
N 1290 -480 1420 -480 { lab=#net5}
N 1780 -400 1780 -240 { lab=#net6}
N 1780 -570 1780 -400 { lab=#net6}
N 1780 -780 1780 -610 { lab=#net4}
N 880 -560 880 270 { lab=Vinn}
N 880 -1520 880 -620 { lab=Vinp}
N 800 -560 1010 -560 { lab=Vinn}
N 800 -620 1010 -620 { lab=Vinp}
N 1290 -1180 1780 -1180 { lab=#net4}
N 1780 -1180 1780 -910 { lab=#net4}
N 1290 -0 1780 -0 { lab=#net6}
N 1780 -240 1780 -0 { lab=#net6}
N 2620 -690 3080 -690 { lab=Voutp}
N 2620 -480 3080 -480 { lab=Voutn}
N 3080 -400 3080 -240 { lab=Voutn}
N 3080 -480 3080 -400 { lab=Voutn}
N 2620 -640 2860 -640 { lab=Voutp}
N 2620 -540 2860 -540 { lab=Voutn}
N 2080 -670 2080 -520 { lab=Vcm}
N 880 -1520 2080 -1520 { lab=Vinp}
N 880 270 2050 270 { lab=Vinn}
N 1680 -610 1780 -610 { lab=#net4}
N 1680 -570 1780 -570 { lab=#net6}
N 1780 -240 1920 -240 { lab=#net6}
N 1780 -910 1920 -910 { lab=#net4}
N 2990 -610 3160 -610 { lab=Voutp}
N 2990 -570 3160 -570 { lab=Voutn}
N -840 -910 -590 -910 { lab=#net15}
N -840 -1000 -840 -910 { lab=#net15}
N -960 -1200 -590 -1200 { lab=Vphi1gen}
N -840 -1200 -840 -1100 { lab=Vphi1gen}
N -410 -940 -340 -940 { lab=#net16}
N -410 -1170 -340 -1170 { lab=#net17}
N -240 -1170 -200 -1170 { lab=#net18}
N -100 -1170 -60 -1170 { lab=#net19}
N -240 -940 -200 -940 { lab=#net20}
N -100 -940 -60 -940 { lab=#net21}
N -620 -1140 -590 -1140 { lab=#net21}
N -620 -1140 -620 -1080 { lab=#net21}
N -620 -1080 -60 -1080 { lab=#net21}
N -60 -1080 -60 -940 { lab=#net21}
N -100 -1170 -100 -1030 { lab=#net19}
N -620 -1030 -100 -1030 { lab=#net19}
N -620 -1030 -620 -970 { lab=#net19}
N -620 -970 -590 -970 { lab=#net19}
N 40 -1170 80 -1170 { lab=Vphi1}
N 40 -940 80 -940 { lab=Vphi2}
N 60 -850 130 -850 { lab=Vphi2}
N 60 -940 60 -850 { lab=Vphi2}
N 60 -1090 130 -1090 { lab=Vphi1}
N 60 -1170 60 -1090 { lab=Vphi1}
N -840 -1440 -590 -1440 { lab=#net22}
N -840 -1530 -840 -1440 { lab=#net22}
N -960 -1730 -590 -1730 { lab=VphiF1gen}
N -840 -1730 -840 -1630 { lab=VphiF1gen}
N -410 -1470 -340 -1470 { lab=#net23}
N -410 -1700 -340 -1700 { lab=#net24}
N -240 -1700 -200 -1700 { lab=#net25}
N -100 -1700 -60 -1700 { lab=#net26}
N -240 -1470 -200 -1470 { lab=#net27}
N -100 -1470 -60 -1470 { lab=#net28}
N -620 -1670 -590 -1670 { lab=#net28}
N -620 -1670 -620 -1610 { lab=#net28}
N -620 -1610 -60 -1610 { lab=#net28}
N -60 -1610 -60 -1470 { lab=#net28}
N -100 -1700 -100 -1560 { lab=#net26}
N -620 -1560 -100 -1560 { lab=#net26}
N -620 -1560 -620 -1500 { lab=#net26}
N -620 -1500 -590 -1500 { lab=#net26}
N 40 -1700 80 -1700 { lab=Vf1}
N 40 -1470 80 -1470 { lab=Vf2}
N 60 -1380 130 -1380 { lab=Vf2}
N 60 -1470 60 -1380 { lab=Vf2}
N 60 -1620 130 -1620 { lab=Vf1}
N 60 -1700 60 -1620 { lab=Vf1}
N -270 -750 -270 -720 { lab=Vbp}
N -270 -720 -240 -720 { lab=Vbp}
N -270 -750 -160 -750 { lab=Vbp}
N -160 -720 -160 -690 { lab=Vbn}
N -160 -720 -130 -720 { lab=Vbn}
N 230 -1380 250 -1380 { lab=Vnf2}
N 230 -1620 250 -1620 { lab=Vnf1}
N 90 2210 90 2260 { lab=Q0}
N 320 2210 320 2260 { lab=Q1}
N 560 2210 560 2260 { lab=Q2}
N -340 2260 -70 2260 { lab=Q16}
N -100 2310 -70 2310 { lab=nQ16}
N -10 2350 -10 2470 { lab=CLK}
N 20 2260 150 2260 { lab=Q0}
N 20 2310 150 2310 { lab=#net29}
N 240 2260 380 2260 { lab=Q1}
N 470 2260 620 2260 { lab=Q2}
N 240 2310 380 2310 { lab=#net30}
N 470 2310 620 2310 { lab=#net31}
N 210 2350 210 2470 { lab=CLK}
N 440 2350 440 2470 { lab=CLK}
N 680 2350 680 2470 { lab=CLK}
N 180 2200 180 2230 { lab=VDD}
N 410 2200 410 2230 { lab=VDD}
N 650 2200 650 2230 { lab=VDD}
N 800 2210 800 2260 { lab=Q3}
N 710 2260 860 2260 { lab=Q3}
N 710 2310 860 2310 { lab=#net32}
N 920 2350 920 2470 { lab=CLK}
N 890 2200 890 2230 { lab=VDD}
N 1040 2210 1040 2260 { lab=Q4}
N 950 2260 1100 2260 { lab=Q4}
N 950 2310 1100 2310 { lab=#net33}
N 1160 2350 1160 2470 { lab=CLK}
N 1130 2200 1130 2230 { lab=VDD}
N 1280 2210 1280 2260 { lab=Q5}
N 1190 2260 1340 2260 { lab=Q5}
N 1190 2310 1340 2310 { lab=#net34}
N 1400 2350 1400 2470 { lab=CLK}
N 1370 2200 1370 2230 { lab=VDD}
N 1520 2210 1520 2260 { lab=Q6}
N 1430 2260 1580 2260 { lab=Q6}
N 1430 2310 1580 2310 { lab=#net35}
N 1610 2200 1610 2230 { lab=VDD}
N -200 2470 1640 2470 { lab=CLK}
N 1760 2210 1760 2260 { lab=Q7}
N 1670 2260 1820 2260 { lab=Q7}
N 1670 2310 1820 2310 { lab=#net36}
N 1850 2200 1850 2230 { lab=VDD}
N 2000 2210 2000 2260 { lab=Q8}
N 1910 2260 2060 2260 { lab=Q8}
N 1910 2310 2060 2310 { lab=#net37}
N 2090 2200 2090 2230 { lab=VDD}
N 2240 2210 2240 2260 { lab=Q9}
N 2150 2260 2300 2260 { lab=Q9}
N 2150 2310 2300 2310 { lab=#net38}
N 2330 2200 2330 2230 { lab=VDD}
N 2480 2210 2480 2260 { lab=Q10}
N 2390 2260 2540 2260 { lab=Q10}
N 2390 2310 2540 2310 { lab=#net39}
N 2570 2200 2570 2230 { lab=VDD}
N 2720 2210 2720 2260 { lab=Q11}
N 2630 2260 2780 2260 { lab=Q11}
N 2630 2310 2780 2310 { lab=#net40}
N 2810 2200 2810 2230 { lab=VDD}
N 2960 2210 2960 2260 { lab=Q12}
N 2870 2260 3020 2260 { lab=Q12}
N 2870 2310 3020 2310 { lab=#net41}
N 3050 2200 3050 2230 { lab=VDD}
N 3200 2210 3200 2260 { lab=Q13}
N 3110 2260 3260 2260 { lab=Q13}
N 3110 2310 3260 2310 { lab=#net42}
N 3290 2200 3290 2230 { lab=VDD}
N 3440 2210 3440 2260 { lab=Q14}
N 3350 2260 3500 2260 { lab=Q14}
N 3350 2310 3500 2310 { lab=#net43}
N 3530 2200 3530 2230 { lab=VDD}
N 3680 2210 3680 2260 { lab=Q15}
N 3590 2260 3740 2260 { lab=Q15}
N 1640 2350 1640 2470 { lab=CLK}
N 1880 2350 1880 2470 { lab=CLK}
N 2120 2350 2120 2470 { lab=CLK}
N 2360 2350 2360 2470 { lab=CLK}
N 2600 2350 2600 2470 { lab=CLK}
N 2840 2350 2840 2470 { lab=CLK}
N 3080 2350 3080 2470 { lab=CLK}
N 3320 2350 3320 2470 { lab=CLK}
N 3560 2350 3560 2470 { lab=CLK}
N 1640 2470 3560 2470 { lab=CLK}
N 3590 2310 3740 2310 { lab=#net44}
N 3800 2350 3800 2470 { lab=CLK}
N 3560 2470 3800 2470 { lab=CLK}
N 3770 2210 3770 2230 { lab=VDD}
N 330 1750 400 1750 { lab=#net45}
N 650 1750 720 1750 { lab=#net46}
N 430 1780 430 1840 { lab=#net47}
N 430 1830 750 1830 { lab=#net47}
N 750 1780 750 1840 { lab=#net47}
N 970 1750 1040 1750 { lab=#net48}
N 750 1830 1070 1830 { lab=#net47}
N 1070 1780 1070 1840 { lab=#net47}
N 1290 1750 1360 1750 { lab=#net49}
N 1070 1830 1390 1830 { lab=#net47}
N 1390 1780 1390 1840 { lab=#net47}
N 1610 1750 1680 1750 { lab=#net50}
N 1390 1830 1710 1830 { lab=#net47}
N 1710 1780 1710 1840 { lab=#net47}
N 1930 1750 2000 1750 { lab=#net51}
N 1710 1830 2030 1830 { lab=#net47}
N 2030 1780 2030 1840 { lab=#net47}
N 2250 1750 2320 1750 { lab=#net52}
N 2030 1830 2350 1830 { lab=#net47}
N 2350 1780 2350 1840 { lab=#net47}
N 2570 1750 2640 1750 { lab=#net53}
N 2350 1830 2670 1830 { lab=#net47}
N 2670 1780 2670 1840 { lab=#net47}
N 2670 1830 2900 1830 { lab=#net47}
N 3250 1830 3330 1830 { lab=Vphi1gen}
N 3080 1830 3150 1830 { lab=#net54}
N 2900 1830 2980 1830 { lab=#net47}
N 3830 2310 3900 2310 { lab=nQ16}
N 3900 2310 3900 2520 { lab=nQ16}
N -370 2520 3900 2520 { lab=nQ16}
N -370 2310 -100 2310 { lab=nQ16}
N -370 2310 -370 2520 { lab=nQ16}
N 3830 2260 3900 2260 { lab=Q16}
N 3900 2110 3900 2260 { lab=Q16}
N -370 2260 -340 2260 { lab=Q16}
N -370 2110 3900 2110 { lab=Q16}
N -370 2110 -370 2260 { lab=Q16}
N -390 1390 -320 1390 { lab=#net55}
N -70 1390 0 1390 { lab=#net56}
N -290 1470 30 1470 { lab=#net57}
N 250 1390 320 1390 { lab=#net58}
N 30 1470 350 1470 { lab=#net57}
N 570 1390 640 1390 { lab=#net59}
N 350 1470 670 1470 { lab=#net57}
N 890 1390 960 1390 { lab=#net60}
N 670 1470 990 1470 { lab=#net57}
N 1210 1390 1280 1390 { lab=#net61}
N 990 1470 1310 1470 { lab=#net57}
N 1530 1390 1600 1390 { lab=#net62}
N 1310 1470 1630 1470 { lab=#net57}
N 1630 1420 1630 1480 { lab=#net57}
N 3820 1470 3900 1470 { lab=VphiF1gen}
N 3650 1470 3720 1470 { lab=#net63}
N 3470 1470 3550 1470 { lab=#net57}
N -290 1420 -290 1470 { lab=#net57}
N 1840 1470 1840 1480 { lab=#net57}
N 30 1420 30 1470 { lab=#net57}
N 350 1420 350 1470 { lab=#net57}
N 670 1420 670 1470 { lab=#net57}
N 990 1420 990 1470 { lab=#net57}
N 1310 1420 1310 1470 { lab=#net57}
N 1860 1390 1930 1390 { lab=#net64}
N 1960 1420 1960 1470 { lab=#net57}
N 2180 1390 2250 1390 { lab=#net65}
N 2500 1390 2570 1390 { lab=#net66}
N 2280 1470 2600 1470 { lab=#net57}
N 2280 1420 2280 1470 { lab=#net57}
N 2600 1420 2600 1470 { lab=#net57}
N 1630 1470 1960 1470 { lab=#net57}
N 1960 1470 2280 1470 { lab=#net57}
N 2820 1390 2890 1390 { lab=#net67}
N 3140 1390 3210 1390 { lab=#net68}
N 2920 1470 3240 1470 { lab=#net57}
N 2920 1420 2920 1470 { lab=#net57}
N 3240 1420 3240 1470 { lab=#net57}
N 2600 1470 2920 1470 { lab=#net57}
N 3190 1470 3190 1480 { lab=#net57}
N 3350 1470 3350 1480 { lab=#net57}
N 3240 1470 3470 1470 { lab=#net57}
N 320 1110 640 1110 { lab=#net69}
N 640 1110 960 1110 { lab=#net69}
N 960 1110 1280 1110 { lab=#net69}
N 3240 1110 3320 1110 { lab=phieval}
N 3070 1110 3140 1110 { lab=#net70}
N 2890 1110 2970 1110 { lab=#net69}
N 2660 1110 2890 1110 { lab=#net69}
N 210 1110 210 1120 { lab=#net69}
N 0 1110 0 1120 { lab=#net69}
N 0 1110 320 1110 { lab=#net69}
N 610 1110 610 1120 { lab=#net69}
N 400 1110 400 1120 { lab=#net69}
N 1020 1110 1020 1120 { lab=#net69}
N 810 1110 810 1120 { lab=#net69}
N 1210 1110 1210 1120 { lab=#net69}
N 1220 1030 1290 1030 { lab=#net71}
N 1320 1060 1320 1110 { lab=#net69}
N 1700 1110 2020 1110 { lab=#net69}
N 2020 1110 2340 1110 { lab=#net69}
N 2340 1110 2660 1110 { lab=#net69}
N 1590 1110 1590 1120 { lab=#net69}
N 1380 1110 1380 1120 { lab=#net69}
N 1380 1110 1700 1110 { lab=#net69}
N 1990 1110 1990 1120 { lab=#net69}
N 1780 1110 1780 1120 { lab=#net69}
N 2400 1110 2400 1120 { lab=#net69}
N 2190 1110 2190 1120 { lab=#net69}
N 2590 1110 2590 1120 { lab=#net69}
N 1280 1110 1380 1110 { lab=#net69}
N 2560 1030 2630 1030 { lab=#net72}
N 2660 1060 2660 1110 { lab=#net69}
N 250 700 320 700 { lab=#net73}
N 570 700 640 700 { lab=#net74}
N 350 730 350 790 { lab=#net75}
N 350 780 670 780 { lab=#net75}
N 670 730 670 790 { lab=#net75}
N 890 700 960 700 { lab=#net76}
N 670 780 990 780 { lab=#net75}
N 990 730 990 790 { lab=#net75}
N 1210 700 1280 700 { lab=#net77}
N 990 780 1310 780 { lab=#net75}
N 1310 730 1310 790 { lab=#net75}
N 1530 700 1600 700 { lab=#net78}
N 1310 780 1630 780 { lab=#net75}
N 1630 730 1630 790 { lab=#net75}
N 1850 700 1920 700 { lab=#net79}
N 1630 780 1950 780 { lab=#net75}
N 1950 730 1950 790 { lab=#net75}
N 2170 700 2240 700 { lab=#net80}
N 1950 780 2270 780 { lab=#net75}
N 2270 730 2270 790 { lab=#net75}
N 2490 700 2560 700 { lab=#net81}
N 2270 780 2590 780 { lab=#net75}
N 2590 730 2590 790 { lab=#net75}
N 2590 780 2820 780 { lab=#net75}
N 3170 780 3250 780 { lab=bs}
N 3000 780 3070 780 { lab=#net82}
N 2820 780 2900 780 { lab=#net75}
C {madvlsi/capacitor.sym} 1040 -620 1 0 {name=C8
value=1p
m=1}
C {madvlsi/capacitor.sym} 1040 -560 1 0 {name=C9
value=1p
m=1}
C {madvlsi/capacitor.sym} 1600 -780 1 0 {name=C17
value=1p
m=1}
C {madvlsi/capacitor.sym} 1600 -400 1 0 {name=C18
value=1p
m=1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1260 -690 0 0 {name=X23 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1260 -480 0 0 {name=X24 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1260 -1180 0 0 {name=X25 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1260 0 0 0 {name=X26 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1600 -910 0 0 {name=X27 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1600 -240 0 0 {name=X28 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1950 -910 0 0 {name=X3 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1950 -240 0 0 {name=X21 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2230 -910 0 0 {name=X29 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2230 -240 0 0 {name=X30 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/capacitor.sym} 2900 -780 1 0 {name=C19
value=1p
m=1}
C {madvlsi/capacitor.sym} 2900 -400 1 0 {name=C20
value=1p
m=1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2900 -910 0 0 {name=X34 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2900 -240 0 0 {name=X35 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/capacitor.sym} 2080 -910 1 0 {name=C21
value=2p
m=1}
C {madvlsi/capacitor.sym} 2080 -240 1 0 {name=C22
value=2p
m=1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2020 -360 1 0 {name=X36 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2150 -350 3 0 {name=X37 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2020 -790 1 0 {name=X38 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2150 -790 3 0 {name=X39 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/capacitor.sym} 2110 -1520 1 0 {name=C23
value=1p
m=1}
C {madvlsi/capacitor.sym} 2110 -1420 1 0 {name=C24
value=1p
m=7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1990 -1420 0 0 {name=X40 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2360 -1450 1 0 {name=X41 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2510 -1520 0 0 {name=X42 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/capacitor.sym} 2080 170 1 0 {name=C25
value=1p
m=7}
C {madvlsi/capacitor.sym} 2080 270 1 0 {name=C26
value=1p
m=1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1970 170 0 0 {name=X43 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2510 270 0 0 {name=X44 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2400 190 1 0 {name=X45 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/fully_differential_sc_amp.sym} 1660 -630 0 0 {name=X2 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/fully_differential_sc_amp.sym} 2970 -630 0 0 {name=X31 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {devices/lab_pin.sym} 1250 -670 3 0 {name=l3 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 1270 -670 3 0 {name=l4 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 1250 -460 3 0 {name=l5 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 1270 -460 3 0 {name=l6 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 1250 -1160 3 0 {name=l7 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 1270 -1160 3 0 {name=l8 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 1250 20 3 0 {name=l9 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 1270 20 3 0 {name=l10 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 1590 -890 3 0 {name=l11 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 1610 -890 3 0 {name=l12 sig_type=std_logic lab=nreset}
C {devices/lab_pin.sym} 1590 -220 3 0 {name=l13 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 1610 -220 3 0 {name=l14 sig_type=std_logic lab=nreset}
C {devices/lab_pin.sym} 1940 -890 3 0 {name=l1 sig_type=std_logic lab=Vf2}
C {devices/lab_pin.sym} 1960 -890 3 0 {name=l2 sig_type=std_logic lab=Vnf2}
C {devices/lab_pin.sym} 1980 -1400 3 0 {name=l15 sig_type=std_logic lab=nbs}
C {devices/lab_pin.sym} 2000 -1400 3 0 {name=l16 sig_type=std_logic lab=bs}
C {devices/lab_pin.sym} 1960 190 3 0 {name=l17 sig_type=std_logic lab=nbs}
C {devices/lab_pin.sym} 1980 190 3 0 {name=l18 sig_type=std_logic lab=bs}
C {devices/lab_pin.sym} 2400 140 1 0 {name=l19 sig_type=std_logic lab=Vcm}
C {devices/lab_pin.sym} 2360 -1400 3 0 {name=l20 sig_type=std_logic lab=Vcm}
C {devices/lab_pin.sym} 2380 180 0 0 {name=l21 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 2380 200 0 0 {name=l22 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 2340 -1460 0 0 {name=l23 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 2340 -1440 0 0 {name=l24 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 2500 290 3 0 {name=l25 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 2520 290 3 0 {name=l26 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 2500 -1500 3 0 {name=l27 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 2520 -1500 3 0 {name=l28 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 2110 -600 2 0 {name=l29 sig_type=std_logic lab=Vcm}
C {devices/lab_pin.sym} 1940 -220 3 0 {name=l30 sig_type=std_logic lab=Vf2}
C {devices/lab_pin.sym} 1960 -220 3 0 {name=l31 sig_type=std_logic lab=Vnf2}
C {devices/lab_pin.sym} 2220 -220 3 0 {name=l32 sig_type=std_logic lab=Vf1}
C {devices/lab_pin.sym} 2240 -220 3 0 {name=l33 sig_type=std_logic lab=Vnf1}
C {devices/lab_pin.sym} 2000 -800 0 0 {name=l34 sig_type=std_logic lab=Vf1}
C {devices/lab_pin.sym} 2000 -780 0 0 {name=l35 sig_type=std_logic lab=Vnf1}
C {devices/lab_pin.sym} 2220 -890 3 0 {name=l36 sig_type=std_logic lab=Vf1}
C {devices/lab_pin.sym} 2240 -890 3 0 {name=l37 sig_type=std_logic lab=Vnf1}
C {devices/lab_pin.sym} 2000 -370 0 0 {name=l38 sig_type=std_logic lab=Vf1}
C {devices/lab_pin.sym} 2000 -350 0 0 {name=l39 sig_type=std_logic lab=Vnf1}
C {devices/lab_pin.sym} 2170 -800 2 0 {name=l40 sig_type=std_logic lab=Vf2}
C {devices/lab_pin.sym} 2170 -780 2 0 {name=l41 sig_type=std_logic lab=Vnf2}
C {devices/lab_pin.sym} 2170 -360 2 0 {name=l42 sig_type=std_logic lab=Vf2}
C {devices/lab_pin.sym} 2170 -340 2 0 {name=l43 sig_type=std_logic lab=Vnf2}
C {devices/lab_pin.sym} 2890 -890 3 0 {name=l44 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 2910 -890 3 0 {name=l45 sig_type=std_logic lab=nreset}
C {devices/lab_pin.sym} 2890 -220 3 0 {name=l46 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 2910 -220 3 0 {name=l47 sig_type=std_logic lab=nreset}
C {devices/lab_pin.sym} 1550 -610 0 0 {name=l48 sig_type=std_logic lab=Vbp}
C {devices/lab_pin.sym} 1550 -590 0 0 {name=l49 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 1550 -570 0 0 {name=l50 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} 2860 -610 0 0 {name=l51 sig_type=std_logic lab=Vbp}
C {devices/lab_pin.sym} 2860 -590 0 0 {name=l52 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 2860 -570 0 0 {name=l53 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} 800 -620 0 0 {name=l54 sig_type=std_logic lab=Vinp}
C {devices/lab_pin.sym} 800 -560 0 0 {name=l55 sig_type=std_logic lab=Vinn}
C {devices/lab_pin.sym} 3160 -610 2 0 {name=l56 sig_type=std_logic lab=Voutp}
C {devices/lab_pin.sym} 3160 -570 2 0 {name=l57 sig_type=std_logic lab=Voutn}
C {madvlsi/vsource.sym} 800 -590 0 0 {name=Vin
value="SIN(0.9 0.9 500000)"}
C {madvlsi/vsource.sym} -480 -680 0 0 {name=Vdd
value=1.8}
C {madvlsi/gnd.sym} -480 -650 0 0 {name=l59 lab=GND}
C {madvlsi/vdd.sym} -480 -710 0 0 {name=l61 lab=VDD}
C {madvlsi/tt_models.sym} 30 -660 0 0 {
name=TT_MODELS
only_toplevel=false
value=".option wnflag=1
.param MC_SWITCH=0.0
.lib ~/skywater/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/sky130.lib.spice tt"
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/nor2.sym} -510 -1170 0 0 {name=X1 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/nor2.sym} -510 -940 0 0 {name=X4 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -300 -1170 0 0 {name=X5}
C {madvlsi/vdd.sym} -300 -1210 0 0 {name=l68 lab=VDD}
C {madvlsi/gnd.sym} -300 -1130 0 0 {name=l69 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -300 -940 0 0 {name=X6}
C {madvlsi/vdd.sym} -300 -980 0 0 {name=l78 lab=VDD}
C {madvlsi/gnd.sym} -300 -900 0 0 {name=l79 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -160 -1170 0 0 {name=X7}
C {madvlsi/vdd.sym} -160 -1210 0 0 {name=l80 lab=VDD}
C {madvlsi/gnd.sym} -160 -1130 0 0 {name=l81 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -160 -940 0 0 {name=X10}
C {madvlsi/vdd.sym} -160 -980 0 0 {name=l82 lab=VDD}
C {madvlsi/gnd.sym} -160 -900 0 0 {name=l83 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -20 -1170 0 0 {name=X11}
C {madvlsi/vdd.sym} -20 -1210 0 0 {name=l84 lab=VDD}
C {madvlsi/gnd.sym} -20 -1130 0 0 {name=l85 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -20 -940 0 0 {name=X12}
C {madvlsi/vdd.sym} -20 -980 0 0 {name=l86 lab=VDD}
C {madvlsi/gnd.sym} -20 -900 0 0 {name=l87 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -840 -1060 1 0 {name=X13}
C {madvlsi/vdd.sym} -800 -1060 1 0 {name=l88 lab=VDD}
C {madvlsi/gnd.sym} -880 -1060 1 0 {name=l89 lab=GND}
C {devices/lab_pin.sym} -960 -1200 0 0 {name=l90 sig_type=std_logic lab=Vphi1gen}
C {devices/lab_pin.sym} 80 -1170 2 0 {name=l62 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 80 -940 2 0 {name=l63 sig_type=std_logic lab=Vphi2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 170 -1090 0 0 {name=X14}
C {madvlsi/vdd.sym} 170 -1130 0 0 {name=l91 lab=VDD}
C {madvlsi/gnd.sym} 170 -1050 0 0 {name=l92 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 170 -850 0 0 {name=X15}
C {madvlsi/vdd.sym} 170 -890 0 0 {name=l93 lab=VDD}
C {madvlsi/gnd.sym} 170 -810 0 0 {name=l94 lab=GND}
C {devices/lab_pin.sym} 230 -1090 2 0 {name=l95 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 230 -850 2 0 {name=l96 sig_type=std_logic lab=Vnphi2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/nor2.sym} -510 -1700 0 0 {name=X16 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/nor2.sym} -510 -1470 0 0 {name=X17 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -300 -1700 0 0 {name=X18}
C {madvlsi/vdd.sym} -300 -1740 0 0 {name=l97 lab=VDD}
C {madvlsi/gnd.sym} -300 -1660 0 0 {name=l98 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -300 -1470 0 0 {name=X19}
C {madvlsi/vdd.sym} -300 -1510 0 0 {name=l99 lab=VDD}
C {madvlsi/gnd.sym} -300 -1430 0 0 {name=l100 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -160 -1700 0 0 {name=X20}
C {madvlsi/vdd.sym} -160 -1740 0 0 {name=l101 lab=VDD}
C {madvlsi/gnd.sym} -160 -1660 0 0 {name=l102 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -160 -1470 0 0 {name=X22}
C {madvlsi/vdd.sym} -160 -1510 0 0 {name=l103 lab=VDD}
C {madvlsi/gnd.sym} -160 -1430 0 0 {name=l104 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -20 -1700 0 0 {name=X32}
C {madvlsi/vdd.sym} -20 -1740 0 0 {name=l105 lab=VDD}
C {madvlsi/gnd.sym} -20 -1660 0 0 {name=l106 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -20 -1470 0 0 {name=X33}
C {madvlsi/vdd.sym} -20 -1510 0 0 {name=l107 lab=VDD}
C {madvlsi/gnd.sym} -20 -1430 0 0 {name=l108 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -840 -1590 1 0 {name=X46}
C {madvlsi/vdd.sym} -800 -1590 1 0 {name=l109 lab=VDD}
C {madvlsi/gnd.sym} -880 -1590 1 0 {name=l110 lab=GND}
C {devices/lab_pin.sym} 80 -1700 2 0 {name=l112 sig_type=std_logic lab=Vf1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 170 -1620 0 0 {name=X47}
C {madvlsi/vdd.sym} 170 -1660 0 0 {name=l114 lab=VDD}
C {madvlsi/gnd.sym} 170 -1580 0 0 {name=l115 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 170 -1380 0 0 {name=X48}
C {madvlsi/vdd.sym} 170 -1420 0 0 {name=l116 lab=VDD}
C {madvlsi/gnd.sym} 170 -1340 0 0 {name=l117 lab=GND}
C {devices/lab_pin.sym} 250 -1380 2 0 {name=l119 sig_type=std_logic lab=Vnf2}
C {devices/lab_pin.sym} -960 -1730 0 0 {name=l120 sig_type=std_logic lab=VphiF1gen}
C {devices/lab_pin.sym} 250 -1620 2 0 {name=l111 sig_type=std_logic lab=Vnf1}
C {devices/lab_pin.sym} 80 -1470 2 0 {name=l118 sig_type=std_logic lab=Vf2}
C {devices/code_shown.sym} 40 -500 0 0 {name=SPICE only_toplevel=false value=".param WW=6 LL=1 Wp=6 Lp=1
.ic v(Q0)=0  v(X49.Qi)=1.8
.ic v(Q1)=0 v(X50.Qi)=1.8
.ic v(Q2)=0 v(X51.Qi)=1.8
.ic v(Q3)=0 v(X52.Qi)=1.8
.ic v(Q4)=0 v(X53.Qi)=1.8
.ic v(Q5)=0 v(X54.Qi)=1.8
.ic v(Q6)=0 v(X55.Qi)=1.8
.ic v(Q7)=0 v(X56.Qi)=1.8
.ic v(Q8)=0 v(X57.Qi)=1.8
.ic v(Q9)=0 v(X58.Qi)=1.8
.ic v(Q10)=0 v(X59.Qi)=1.8
.ic v(Q11)=0 v(X60.Qi)=1.8
.ic v(Q12)=0 v(X61.Qi)=1.8
.ic v(Q13)=0 v(X62.Qi)=1.8
.ic v(Q14)=0 v(X63.Qi)=1.8
.ic v(Q15)=0 v(X64.Qi)=1.8
.ic v(Q16)=1.8 v(X64.Qi)=0 v(nQ16)=0
.tran 5u 10m
.save all"}
C {madvlsi/vsource.sym} -380 -680 0 0 {name=Vref
value=0.9}
C {madvlsi/gnd.sym} -380 -650 0 0 {name=l113 lab=GND}
C {devices/lab_pin.sym} -270 -750 1 0 {name=l64 sig_type=std_logic lab=Vbp}
C {madvlsi/pmos3.sym} -240 -750 0 0 {name=M5
L=1
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/isource.sym} -240 -690 0 0 {name=I1
value=1u}
C {madvlsi/vdd.sym} -240 -780 0 0 {name=l65 lab=VDD}
C {madvlsi/gnd.sym} -240 -660 0 0 {name=l66 lab=GND}
C {madvlsi/pmos3.sym} -130 -750 0 0 {name=M1
L=1
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} -130 -780 0 0 {name=l67 lab=VDD}
C {madvlsi/nmos3.sym} -130 -690 0 0 {name=M2
L=LL
W=WW
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -160 -690 0 0 {name=l70 sig_type=std_logic lab=Vbn}
C {madvlsi/gnd.sym} -130 -660 0 0 {name=l71 lab=GND}
C {devices/lab_pin.sym} -380 -710 1 0 {name=l72 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} -370 -480 1 0 {name=l73 sig_type=std_logic lab=reset}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -160 -280 0 0 {name=X8}
C {madvlsi/vdd.sym} -160 -320 0 0 {name=l124 lab=VDD}
C {madvlsi/gnd.sym} -160 -240 0 0 {name=l125 lab=GND}
C {devices/lab_pin.sym} -100 -280 2 0 {name=l126 sig_type=std_logic lab=nbs}
C {devices/lab_pin.sym} -200 -280 0 0 {name=l127 sig_type=std_logic lab=bs}
C {madvlsi/vsource.sym} -370 -450 0 0 {name=Vreset
value="PWL(0u 0 +16 0)"}
C {madvlsi/gnd.sym} -370 -420 0 0 {name=l76 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -160 -450 0 0 {name=X9}
C {madvlsi/vdd.sym} -160 -490 0 0 {name=l77 lab=VDD}
C {madvlsi/gnd.sym} -160 -410 0 0 {name=l121 lab=GND}
C {devices/lab_pin.sym} -100 -450 2 0 {name=l128 sig_type=std_logic lab=nreset}
C {devices/lab_pin.sym} -200 -450 0 0 {name=l129 sig_type=std_logic lab=reset}
C {madvlsi/gnd.sym} -40 2350 0 0 {name=l58 lab=GND}
C {madvlsi/gnd.sym} 180 2350 0 0 {name=l60 lab=GND}
C {madvlsi/gnd.sym} 410 2350 0 0 {name=l74 lab=GND}
C {madvlsi/gnd.sym} 650 2350 0 0 {name=l75 lab=GND}
C {madvlsi/vdd.sym} -40 2230 0 0 {name=l122 lab=VDD}
C {madvlsi/vdd.sym} 180 2200 0 0 {name=l123 lab=VDD}
C {madvlsi/vdd.sym} 410 2200 0 0 {name=l130 lab=VDD}
C {madvlsi/vdd.sym} 650 2200 0 0 {name=l131 lab=VDD}
C {devices/lab_pin.sym} -200 2470 0 0 {name=l132 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 90 2210 1 0 {name=l133 sig_type=std_logic lab=Q0}
C {devices/lab_pin.sym} 320 2210 1 0 {name=l134 sig_type=std_logic lab=Q1}
C {devices/lab_pin.sym} 560 2210 1 0 {name=l135 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 800 2210 1 0 {name=l136 sig_type=std_logic lab=Q3}
C {madvlsi/vsource.sym} -620 -450 0 0 {name=VCLK
value="pulse(0 1.8 20u 1n 1n 5u 10u)"}
C {madvlsi/gnd.sym} -620 -420 0 0 {name=l138 lab=GND}
C {devices/lab_pin.sym} -620 -480 0 0 {name=l141 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} -200 2470 0 0 {name=l142 sig_type=std_logic lab=CLK}
C {madvlsi/gnd.sym} 890 2350 0 0 {name=l144 lab=GND}
C {madvlsi/vdd.sym} 890 2200 0 0 {name=l145 lab=VDD}
C {madvlsi/gnd.sym} 1130 2350 0 0 {name=l146 lab=GND}
C {madvlsi/vdd.sym} 1130 2200 0 0 {name=l147 lab=VDD}
C {devices/lab_pin.sym} 1040 2210 1 0 {name=l148 sig_type=std_logic lab=Q4}
C {madvlsi/gnd.sym} 1370 2350 0 0 {name=l149 lab=GND}
C {madvlsi/vdd.sym} 1370 2200 0 0 {name=l150 lab=VDD}
C {devices/lab_pin.sym} 1280 2210 1 0 {name=l151 sig_type=std_logic lab=Q5}
C {madvlsi/gnd.sym} 1610 2350 0 0 {name=l152 lab=GND}
C {madvlsi/vdd.sym} 1610 2200 0 0 {name=l153 lab=VDD}
C {devices/lab_pin.sym} 1520 2210 1 0 {name=l154 sig_type=std_logic lab=Q6}
C {madvlsi/gnd.sym} 1850 2350 0 0 {name=l155 lab=GND}
C {madvlsi/vdd.sym} 1850 2200 0 0 {name=l156 lab=VDD}
C {devices/lab_pin.sym} 1760 2210 1 0 {name=l157 sig_type=std_logic lab=Q7}
C {madvlsi/gnd.sym} 2090 2350 0 0 {name=l158 lab=GND}
C {madvlsi/vdd.sym} 2090 2200 0 0 {name=l159 lab=VDD}
C {devices/lab_pin.sym} 2000 2210 1 0 {name=l160 sig_type=std_logic lab=Q8}
C {madvlsi/gnd.sym} 2330 2350 0 0 {name=l161 lab=GND}
C {madvlsi/vdd.sym} 2330 2200 0 0 {name=l162 lab=VDD}
C {devices/lab_pin.sym} 2240 2210 1 0 {name=l163 sig_type=std_logic lab=Q9}
C {madvlsi/gnd.sym} 2570 2350 0 0 {name=l164 lab=GND}
C {madvlsi/vdd.sym} 2570 2200 0 0 {name=l165 lab=VDD}
C {devices/lab_pin.sym} 2480 2210 1 0 {name=l166 sig_type=std_logic lab=Q10}
C {madvlsi/gnd.sym} 2810 2350 0 0 {name=l167 lab=GND}
C {madvlsi/vdd.sym} 2810 2200 0 0 {name=l168 lab=VDD}
C {devices/lab_pin.sym} 2720 2210 1 0 {name=l169 sig_type=std_logic lab=Q11}
C {madvlsi/gnd.sym} 3050 2350 0 0 {name=l170 lab=GND}
C {madvlsi/vdd.sym} 3050 2200 0 0 {name=l171 lab=VDD}
C {devices/lab_pin.sym} 2960 2210 1 0 {name=l172 sig_type=std_logic lab=Q12}
C {madvlsi/gnd.sym} 3290 2350 0 0 {name=l173 lab=GND}
C {madvlsi/vdd.sym} 3290 2200 0 0 {name=l174 lab=VDD}
C {devices/lab_pin.sym} 3200 2210 1 0 {name=l175 sig_type=std_logic lab=Q13}
C {madvlsi/gnd.sym} 3530 2350 0 0 {name=l176 lab=GND}
C {madvlsi/vdd.sym} 3530 2200 0 0 {name=l177 lab=VDD}
C {devices/lab_pin.sym} 3440 2210 1 0 {name=l178 sig_type=std_logic lab=Q14}
C {devices/lab_pin.sym} 3680 2210 1 0 {name=l179 sig_type=std_logic lab=Q15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} -120 2290 0 0 {name=X49}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 100 2290 0 0 {name=X50}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 330 2290 0 0 {name=X51}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 570 2290 0 0 {name=X52}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 810 2290 0 0 {name=X53}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 1050 2290 0 0 {name=X54}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 1290 2290 0 0 {name=X55}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 1530 2290 0 0 {name=X56}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 1770 2290 0 0 {name=X57}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 2010 2290 0 0 {name=X58}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 2250 2290 0 0 {name=X59}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 2490 2290 0 0 {name=X60}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 2730 2290 0 0 {name=X61}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 2970 2290 0 0 {name=X62}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 3210 2290 0 0 {name=X63}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 3690 2290 0 0 {name=X64}
C {madvlsi/gnd.sym} 3770 2350 0 0 {name=l180 lab=GND}
C {madvlsi/vdd.sym} 3770 2210 0 0 {name=l181 lab=VDD}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 3450 2290 0 0 {name=X65}
C {madvlsi/pmos3.sym} 430 1750 0 0 {name=M3
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 750 1750 0 0 {name=M4
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 270 1750 0 0 {name=X66 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 590 1750 0 0 {name=X67 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/nmos3.sym} 430 1870 0 0 {name=M6
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 750 1870 0 0 {name=M7
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 270 1790 0 0 {name=l182 lab=GND}
C {madvlsi/vdd.sym} 270 1710 0 0 {name=l183 lab=VDD}
C {madvlsi/gnd.sym} 590 1790 0 0 {name=l184 lab=GND}
C {madvlsi/vdd.sym} 590 1710 0 0 {name=l185 lab=VDD}
C {madvlsi/vdd.sym} 430 1720 0 0 {name=l186 lab=VDD}
C {madvlsi/vdd.sym} 750 1720 0 0 {name=l187 lab=VDD}
C {madvlsi/gnd.sym} 430 1900 0 0 {name=l188 lab=GND}
C {madvlsi/gnd.sym} 750 1900 0 0 {name=l189 lab=GND}
C {devices/lab_pin.sym} 230 1750 0 0 {name=l190 sig_type=std_logic lab=Q0}
C {madvlsi/pmos3.sym} 1070 1750 0 0 {name=M8
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 910 1750 0 0 {name=X68 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/nmos3.sym} 1070 1870 0 0 {name=M9
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 910 1790 0 0 {name=l191 lab=GND}
C {madvlsi/vdd.sym} 910 1710 0 0 {name=l192 lab=VDD}
C {madvlsi/vdd.sym} 1070 1720 0 0 {name=l193 lab=VDD}
C {madvlsi/gnd.sym} 1070 1900 0 0 {name=l194 lab=GND}
C {madvlsi/pmos3.sym} 1390 1750 0 0 {name=M10
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1230 1750 0 0 {name=X69 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/nmos3.sym} 1390 1870 0 0 {name=M11
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1230 1790 0 0 {name=l195 lab=GND}
C {madvlsi/vdd.sym} 1230 1710 0 0 {name=l196 lab=VDD}
C {madvlsi/vdd.sym} 1390 1720 0 0 {name=l197 lab=VDD}
C {madvlsi/gnd.sym} 1390 1900 0 0 {name=l198 lab=GND}
C {madvlsi/pmos3.sym} 1710 1750 0 0 {name=M12
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1550 1750 0 0 {name=X70 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/nmos3.sym} 1710 1870 0 0 {name=M13
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1550 1790 0 0 {name=l199 lab=GND}
C {madvlsi/vdd.sym} 1550 1710 0 0 {name=l200 lab=VDD}
C {madvlsi/vdd.sym} 1710 1720 0 0 {name=l201 lab=VDD}
C {madvlsi/gnd.sym} 1710 1900 0 0 {name=l202 lab=GND}
C {madvlsi/pmos3.sym} 2030 1750 0 0 {name=M14
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1870 1750 0 0 {name=X71 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/nmos3.sym} 2030 1870 0 0 {name=M15
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1870 1790 0 0 {name=l203 lab=GND}
C {madvlsi/vdd.sym} 1870 1710 0 0 {name=l204 lab=VDD}
C {madvlsi/vdd.sym} 2030 1720 0 0 {name=l205 lab=VDD}
C {madvlsi/gnd.sym} 2030 1900 0 0 {name=l206 lab=GND}
C {madvlsi/pmos3.sym} 2350 1750 0 0 {name=M16
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2190 1750 0 0 {name=X72 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/nmos3.sym} 2350 1870 0 0 {name=M17
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2190 1790 0 0 {name=l207 lab=GND}
C {madvlsi/vdd.sym} 2190 1710 0 0 {name=l208 lab=VDD}
C {madvlsi/vdd.sym} 2350 1720 0 0 {name=l209 lab=VDD}
C {madvlsi/gnd.sym} 2350 1900 0 0 {name=l210 lab=GND}
C {madvlsi/pmos3.sym} 2670 1750 0 0 {name=M18
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2510 1750 0 0 {name=X73 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/nmos3.sym} 2670 1870 0 0 {name=M19
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2510 1790 0 0 {name=l211 lab=GND}
C {madvlsi/vdd.sym} 2510 1710 0 0 {name=l212 lab=VDD}
C {madvlsi/vdd.sym} 2670 1720 0 0 {name=l213 lab=VDD}
C {madvlsi/gnd.sym} 2670 1900 0 0 {name=l214 lab=GND}
C {devices/lab_pin.sym} 3330 1830 1 0 {name=l215 sig_type=std_logic lab=Vphi1gen}
C {devices/lab_pin.sym} 550 1750 0 0 {name=l216 sig_type=std_logic lab=Q1}
C {devices/lab_pin.sym} 400 1870 0 0 {name=l217 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 720 1870 0 0 {name=l218 sig_type=std_logic lab=Q3}
C {devices/lab_pin.sym} 870 1750 0 0 {name=l219 sig_type=std_logic lab=Q4}
C {devices/lab_pin.sym} 1190 1750 0 0 {name=l220 sig_type=std_logic lab=Q5}
C {devices/lab_pin.sym} 1040 1870 0 0 {name=l221 sig_type=std_logic lab=Q6}
C {devices/lab_pin.sym} 1360 1870 0 0 {name=l222 sig_type=std_logic lab=Q7}
C {devices/lab_pin.sym} 1510 1750 0 0 {name=l223 sig_type=std_logic lab=Q8}
C {devices/lab_pin.sym} 1830 1750 0 0 {name=l224 sig_type=std_logic lab=Q9}
C {devices/lab_pin.sym} 2150 1750 0 0 {name=l225 sig_type=std_logic lab=Q10}
C {devices/lab_pin.sym} 2470 1750 0 0 {name=l226 sig_type=std_logic lab=Q11}
C {devices/lab_pin.sym} 1680 1870 0 0 {name=l227 sig_type=std_logic lab=Q12}
C {devices/lab_pin.sym} 2000 1870 0 0 {name=l228 sig_type=std_logic lab=Q13}
C {devices/lab_pin.sym} 2320 1870 0 0 {name=l229 sig_type=std_logic lab=Q14}
C {devices/lab_pin.sym} 2640 1870 0 0 {name=l230 sig_type=std_logic lab=Q15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3020 1830 0 0 {name=X74 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3190 1830 0 0 {name=X75 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} 3020 1870 0 0 {name=l231 lab=GND}
C {madvlsi/vdd.sym} 3020 1790 0 0 {name=l232 lab=VDD}
C {madvlsi/gnd.sym} 3190 1870 0 0 {name=l233 lab=GND}
C {madvlsi/vdd.sym} 3190 1790 0 0 {name=l234 lab=VDD}
C {devices/lab_pin.sym} -230 2260 1 0 {name=l236 sig_type=std_logic lab=Q16}
C {devices/lab_pin.sym} -230 2310 1 0 {name=l237 sig_type=std_logic lab=nQ16}
C {madvlsi/pmos3.sym} -290 1390 0 0 {name=M20
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 30 1390 0 0 {name=M21
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -450 1390 0 0 {name=X76 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -130 1390 0 0 {name=X77 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} -450 1430 0 0 {name=l137 lab=GND}
C {madvlsi/vdd.sym} -450 1350 0 0 {name=l139 lab=VDD}
C {madvlsi/gnd.sym} -130 1430 0 0 {name=l140 lab=GND}
C {madvlsi/vdd.sym} -130 1350 0 0 {name=l143 lab=VDD}
C {madvlsi/vdd.sym} -290 1360 0 0 {name=l235 lab=VDD}
C {madvlsi/vdd.sym} 30 1360 0 0 {name=l238 lab=VDD}
C {devices/lab_pin.sym} -490 1390 0 0 {name=l239 sig_type=std_logic lab=Q0}
C {madvlsi/pmos3.sym} 350 1390 0 0 {name=M22
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 190 1390 0 0 {name=X78 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} 190 1430 0 0 {name=l240 lab=GND}
C {madvlsi/vdd.sym} 190 1350 0 0 {name=l241 lab=VDD}
C {madvlsi/vdd.sym} 350 1360 0 0 {name=l242 lab=VDD}
C {madvlsi/pmos3.sym} 670 1390 0 0 {name=M23
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 510 1390 0 0 {name=X79 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} 510 1430 0 0 {name=l243 lab=GND}
C {madvlsi/vdd.sym} 510 1350 0 0 {name=l244 lab=VDD}
C {madvlsi/vdd.sym} 670 1360 0 0 {name=l245 lab=VDD}
C {madvlsi/pmos3.sym} 990 1390 0 0 {name=M24
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 830 1390 0 0 {name=X80 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} 830 1430 0 0 {name=l246 lab=GND}
C {madvlsi/vdd.sym} 830 1350 0 0 {name=l247 lab=VDD}
C {madvlsi/vdd.sym} 990 1360 0 0 {name=l248 lab=VDD}
C {madvlsi/pmos3.sym} 1310 1390 0 0 {name=M25
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1150 1390 0 0 {name=X81 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} 1150 1430 0 0 {name=l249 lab=GND}
C {madvlsi/vdd.sym} 1150 1350 0 0 {name=l250 lab=VDD}
C {madvlsi/vdd.sym} 1310 1360 0 0 {name=l251 lab=VDD}
C {madvlsi/pmos3.sym} 1630 1390 0 0 {name=M26
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1470 1390 0 0 {name=X82 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} 1470 1430 0 0 {name=l252 lab=GND}
C {madvlsi/vdd.sym} 1470 1350 0 0 {name=l253 lab=VDD}
C {madvlsi/vdd.sym} 1630 1360 0 0 {name=l254 lab=VDD}
C {madvlsi/nmos3.sym} 1630 1510 0 0 {name=M27
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1630 1540 0 0 {name=l255 lab=GND}
C {devices/lab_pin.sym} -170 1390 0 0 {name=l257 sig_type=std_logic lab=Q1}
C {devices/lab_pin.sym} 150 1390 0 0 {name=l258 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 470 1390 0 0 {name=l259 sig_type=std_logic lab=Q3}
C {devices/lab_pin.sym} 790 1390 0 0 {name=l260 sig_type=std_logic lab=Q4}
C {devices/lab_pin.sym} 1110 1390 0 0 {name=l261 sig_type=std_logic lab=Q5}
C {devices/lab_pin.sym} 1430 1390 0 0 {name=l262 sig_type=std_logic lab=Q6}
C {devices/lab_pin.sym} 1600 1510 0 0 {name=l263 sig_type=std_logic lab=Q7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3590 1470 0 0 {name=X83 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3760 1470 0 0 {name=X84 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} 3590 1510 0 0 {name=l264 lab=GND}
C {madvlsi/vdd.sym} 3590 1430 0 0 {name=l265 lab=VDD}
C {madvlsi/gnd.sym} 3760 1510 0 0 {name=l266 lab=GND}
C {madvlsi/vdd.sym} 3760 1430 0 0 {name=l267 lab=VDD}
C {madvlsi/nmos3.sym} 1840 1510 0 0 {name=M28
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1840 1540 0 0 {name=l269 lab=GND}
C {devices/lab_pin.sym} 1810 1510 0 0 {name=l270 sig_type=std_logic lab=Q8}
C {madvlsi/pmos3.sym} 1960 1390 0 0 {name=M29
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1800 1390 0 0 {name=X85 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} 1800 1430 0 0 {name=l271 lab=GND}
C {madvlsi/vdd.sym} 1800 1350 0 0 {name=l272 lab=VDD}
C {madvlsi/vdd.sym} 1960 1360 0 0 {name=l273 lab=VDD}
C {devices/lab_pin.sym} 1760 1390 0 0 {name=l274 sig_type=std_logic lab=Q9}
C {madvlsi/pmos3.sym} 2280 1390 0 0 {name=M30
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2120 1390 0 0 {name=X86 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} 2120 1430 0 0 {name=l275 lab=GND}
C {madvlsi/vdd.sym} 2120 1350 0 0 {name=l276 lab=VDD}
C {madvlsi/vdd.sym} 2280 1360 0 0 {name=l277 lab=VDD}
C {madvlsi/pmos3.sym} 2600 1390 0 0 {name=M31
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2440 1390 0 0 {name=X87 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} 2440 1430 0 0 {name=l278 lab=GND}
C {madvlsi/vdd.sym} 2440 1350 0 0 {name=l279 lab=VDD}
C {madvlsi/vdd.sym} 2600 1360 0 0 {name=l280 lab=VDD}
C {devices/lab_pin.sym} 2080 1390 0 0 {name=l281 sig_type=std_logic lab=Q10}
C {devices/lab_pin.sym} 2400 1390 0 0 {name=l282 sig_type=std_logic lab=Q11}
C {madvlsi/pmos3.sym} 2920 1390 0 0 {name=M32
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2760 1390 0 0 {name=X88 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} 2760 1430 0 0 {name=l283 lab=GND}
C {madvlsi/vdd.sym} 2760 1350 0 0 {name=l284 lab=VDD}
C {madvlsi/vdd.sym} 2920 1360 0 0 {name=l285 lab=VDD}
C {madvlsi/pmos3.sym} 3240 1390 0 0 {name=M33
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3080 1390 0 0 {name=X89 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} 3080 1430 0 0 {name=l286 lab=GND}
C {madvlsi/vdd.sym} 3080 1350 0 0 {name=l287 lab=VDD}
C {madvlsi/vdd.sym} 3240 1360 0 0 {name=l288 lab=VDD}
C {devices/lab_pin.sym} 2720 1390 0 0 {name=l289 sig_type=std_logic lab=Q12}
C {devices/lab_pin.sym} 3040 1390 0 0 {name=l290 sig_type=std_logic lab=Q13}
C {madvlsi/nmos3.sym} 3190 1510 0 0 {name=M34
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 3190 1540 0 0 {name=l291 lab=GND}
C {devices/lab_pin.sym} 3160 1510 0 0 {name=l292 sig_type=std_logic lab=Q14}
C {madvlsi/nmos3.sym} 3350 1510 0 0 {name=M35
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 3350 1540 0 0 {name=l293 lab=GND}
C {devices/lab_pin.sym} 3320 1510 0 0 {name=l294 sig_type=std_logic lab=Q15}
C {devices/lab_pin.sym} 3900 1470 1 0 {name=l256 sig_type=std_logic lab=VphiF1gen}
C {devices/lab_pin.sym} 3320 1110 1 0 {name=l268 sig_type=std_logic lab=phieval}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3010 1110 0 0 {name=X90 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3180 1110 0 0 {name=X91 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} 3010 1150 0 0 {name=l295 lab=GND}
C {madvlsi/vdd.sym} 3010 1070 0 0 {name=l296 lab=VDD}
C {madvlsi/gnd.sym} 3180 1150 0 0 {name=l297 lab=GND}
C {madvlsi/vdd.sym} 3180 1070 0 0 {name=l298 lab=VDD}
C {madvlsi/nmos3.sym} 0 1150 0 0 {name=M36
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 0 1180 0 0 {name=l300 lab=GND}
C {devices/lab_pin.sym} -30 1150 0 0 {name=l301 sig_type=std_logic lab=Q0}
C {madvlsi/nmos3.sym} 210 1150 0 0 {name=M37
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 210 1180 0 0 {name=l302 lab=GND}
C {devices/lab_pin.sym} 180 1150 0 0 {name=l303 sig_type=std_logic lab=Q1}
C {madvlsi/nmos3.sym} 400 1150 0 0 {name=M38
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 400 1180 0 0 {name=l304 lab=GND}
C {devices/lab_pin.sym} 370 1150 0 0 {name=l305 sig_type=std_logic lab=Q2}
C {madvlsi/nmos3.sym} 610 1150 0 0 {name=M39
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 610 1180 0 0 {name=l306 lab=GND}
C {devices/lab_pin.sym} 580 1150 0 0 {name=l307 sig_type=std_logic lab=Q3}
C {madvlsi/nmos3.sym} 810 1150 0 0 {name=M40
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 810 1180 0 0 {name=l308 lab=GND}
C {devices/lab_pin.sym} 780 1150 0 0 {name=l309 sig_type=std_logic lab=Q4}
C {madvlsi/nmos3.sym} 1020 1150 0 0 {name=M41
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1020 1180 0 0 {name=l310 lab=GND}
C {devices/lab_pin.sym} 990 1150 0 0 {name=l311 sig_type=std_logic lab=Q5}
C {madvlsi/nmos3.sym} 1210 1150 0 0 {name=M42
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1210 1180 0 0 {name=l312 lab=GND}
C {devices/lab_pin.sym} 1180 1150 0 0 {name=l313 sig_type=std_logic lab=Q6}
C {madvlsi/pmos3.sym} 1320 1030 0 0 {name=M43
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1160 1030 0 0 {name=X92 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} 1160 1070 0 0 {name=l314 lab=GND}
C {madvlsi/vdd.sym} 1160 990 0 0 {name=l315 lab=VDD}
C {madvlsi/vdd.sym} 1320 1000 0 0 {name=l316 lab=VDD}
C {devices/lab_pin.sym} 1120 1030 0 0 {name=l317 sig_type=std_logic lab=Q7}
C {madvlsi/nmos3.sym} 1380 1150 0 0 {name=M44
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1380 1180 0 0 {name=l318 lab=GND}
C {devices/lab_pin.sym} 1350 1150 0 0 {name=l319 sig_type=std_logic lab=Q8}
C {madvlsi/nmos3.sym} 1590 1150 0 0 {name=M45
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1590 1180 0 0 {name=l320 lab=GND}
C {devices/lab_pin.sym} 1560 1150 0 0 {name=l321 sig_type=std_logic lab=Q9}
C {madvlsi/nmos3.sym} 1780 1150 0 0 {name=M46
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1780 1180 0 0 {name=l322 lab=GND}
C {devices/lab_pin.sym} 1750 1150 0 0 {name=l323 sig_type=std_logic lab=Q10}
C {madvlsi/nmos3.sym} 1990 1150 0 0 {name=M47
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1990 1180 0 0 {name=l324 lab=GND}
C {devices/lab_pin.sym} 1960 1150 0 0 {name=l325 sig_type=std_logic lab=Q11}
C {madvlsi/nmos3.sym} 2190 1150 0 0 {name=M48
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2190 1180 0 0 {name=l326 lab=GND}
C {devices/lab_pin.sym} 2160 1150 0 0 {name=l327 sig_type=std_logic lab=Q12}
C {madvlsi/nmos3.sym} 2400 1150 0 0 {name=M49
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2400 1180 0 0 {name=l328 lab=GND}
C {devices/lab_pin.sym} 2370 1150 0 0 {name=l329 sig_type=std_logic lab=Q13}
C {madvlsi/nmos3.sym} 2590 1150 0 0 {name=M50
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2590 1180 0 0 {name=l330 lab=GND}
C {devices/lab_pin.sym} 2560 1150 0 0 {name=l331 sig_type=std_logic lab=Q14}
C {madvlsi/pmos3.sym} 2660 1030 0 0 {name=M51
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2500 1030 0 0 {name=X93 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} 2500 1070 0 0 {name=l332 lab=GND}
C {madvlsi/vdd.sym} 2500 990 0 0 {name=l333 lab=VDD}
C {madvlsi/vdd.sym} 2660 1000 0 0 {name=l334 lab=VDD}
C {devices/lab_pin.sym} 2460 1030 0 0 {name=l335 sig_type=std_logic lab=Q15}
C {madvlsi/pmos3.sym} 350 700 0 0 {name=M52
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 670 700 0 0 {name=M53
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 190 700 0 0 {name=X94 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 510 700 0 0 {name=X95 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/nmos3.sym} 350 820 0 0 {name=M54
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 670 820 0 0 {name=M55
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 190 740 0 0 {name=l299 lab=GND}
C {madvlsi/vdd.sym} 190 660 0 0 {name=l336 lab=VDD}
C {madvlsi/gnd.sym} 510 740 0 0 {name=l337 lab=GND}
C {madvlsi/vdd.sym} 510 660 0 0 {name=l338 lab=VDD}
C {madvlsi/vdd.sym} 350 670 0 0 {name=l339 lab=VDD}
C {madvlsi/vdd.sym} 670 670 0 0 {name=l340 lab=VDD}
C {madvlsi/gnd.sym} 350 850 0 0 {name=l341 lab=GND}
C {madvlsi/gnd.sym} 670 850 0 0 {name=l342 lab=GND}
C {devices/lab_pin.sym} 150 700 0 0 {name=l343 sig_type=std_logic lab=Q0}
C {madvlsi/pmos3.sym} 990 700 0 0 {name=M56
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 830 700 0 0 {name=X96 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/nmos3.sym} 990 820 0 0 {name=M57
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 830 740 0 0 {name=l344 lab=GND}
C {madvlsi/vdd.sym} 830 660 0 0 {name=l345 lab=VDD}
C {madvlsi/vdd.sym} 990 670 0 0 {name=l346 lab=VDD}
C {madvlsi/gnd.sym} 990 850 0 0 {name=l347 lab=GND}
C {madvlsi/pmos3.sym} 1310 700 0 0 {name=M58
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1150 700 0 0 {name=X97 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/nmos3.sym} 1310 820 0 0 {name=M59
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1150 740 0 0 {name=l348 lab=GND}
C {madvlsi/vdd.sym} 1150 660 0 0 {name=l349 lab=VDD}
C {madvlsi/vdd.sym} 1310 670 0 0 {name=l350 lab=VDD}
C {madvlsi/gnd.sym} 1310 850 0 0 {name=l351 lab=GND}
C {madvlsi/pmos3.sym} 1630 700 0 0 {name=M60
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1470 700 0 0 {name=X98 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/nmos3.sym} 1630 820 0 0 {name=M61
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1470 740 0 0 {name=l352 lab=GND}
C {madvlsi/vdd.sym} 1470 660 0 0 {name=l353 lab=VDD}
C {madvlsi/vdd.sym} 1630 670 0 0 {name=l354 lab=VDD}
C {madvlsi/gnd.sym} 1630 850 0 0 {name=l355 lab=GND}
C {madvlsi/pmos3.sym} 1950 700 0 0 {name=M62
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1790 700 0 0 {name=X99 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/nmos3.sym} 1950 820 0 0 {name=M63
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1790 740 0 0 {name=l356 lab=GND}
C {madvlsi/vdd.sym} 1790 660 0 0 {name=l357 lab=VDD}
C {madvlsi/vdd.sym} 1950 670 0 0 {name=l358 lab=VDD}
C {madvlsi/gnd.sym} 1950 850 0 0 {name=l359 lab=GND}
C {madvlsi/pmos3.sym} 2270 700 0 0 {name=M64
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2110 700 0 0 {name=X100 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/nmos3.sym} 2270 820 0 0 {name=M65
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2110 740 0 0 {name=l360 lab=GND}
C {madvlsi/vdd.sym} 2110 660 0 0 {name=l361 lab=VDD}
C {madvlsi/vdd.sym} 2270 670 0 0 {name=l362 lab=VDD}
C {madvlsi/gnd.sym} 2270 850 0 0 {name=l363 lab=GND}
C {madvlsi/pmos3.sym} 2590 700 0 0 {name=M66
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2430 700 0 0 {name=X101 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/nmos3.sym} 2590 820 0 0 {name=M67
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2430 740 0 0 {name=l364 lab=GND}
C {madvlsi/vdd.sym} 2430 660 0 0 {name=l365 lab=VDD}
C {madvlsi/vdd.sym} 2590 670 0 0 {name=l366 lab=VDD}
C {madvlsi/gnd.sym} 2590 850 0 0 {name=l367 lab=GND}
C {devices/lab_pin.sym} 3250 780 1 0 {name=l368 sig_type=std_logic lab=bs}
C {devices/lab_pin.sym} 470 700 0 0 {name=l369 sig_type=std_logic lab=Q1}
C {devices/lab_pin.sym} 320 820 0 0 {name=l370 sig_type=std_logic lab=Q8}
C {devices/lab_pin.sym} 640 820 0 0 {name=l371 sig_type=std_logic lab=Q9}
C {devices/lab_pin.sym} 790 700 0 0 {name=l372 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 1110 700 0 0 {name=l373 sig_type=std_logic lab=Q3}
C {devices/lab_pin.sym} 960 820 0 0 {name=l374 sig_type=std_logic lab=Q10}
C {devices/lab_pin.sym} 1280 820 0 0 {name=l375 sig_type=std_logic lab=Q11}
C {devices/lab_pin.sym} 1430 700 0 0 {name=l376 sig_type=std_logic lab=Q4}
C {devices/lab_pin.sym} 1750 700 0 0 {name=l377 sig_type=std_logic lab=Q5}
C {devices/lab_pin.sym} 2070 700 0 0 {name=l378 sig_type=std_logic lab=Q6}
C {devices/lab_pin.sym} 2390 700 0 0 {name=l379 sig_type=std_logic lab=Q7}
C {devices/lab_pin.sym} 1600 820 0 0 {name=l380 sig_type=std_logic lab=Q12}
C {devices/lab_pin.sym} 1920 820 0 0 {name=l381 sig_type=std_logic lab=Q13}
C {devices/lab_pin.sym} 2240 820 0 0 {name=l382 sig_type=std_logic lab=Q14}
C {devices/lab_pin.sym} 2560 820 0 0 {name=l383 sig_type=std_logic lab=Q15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 2940 780 0 0 {name=X102 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3110 780 0 0 {name=X103 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/gnd.sym} 2940 820 0 0 {name=l384 lab=GND}
C {madvlsi/vdd.sym} 2940 740 0 0 {name=l385 lab=VDD}
C {madvlsi/gnd.sym} 3110 820 0 0 {name=l386 lab=GND}
C {madvlsi/vdd.sym} 3110 740 0 0 {name=l387 lab=VDD}
