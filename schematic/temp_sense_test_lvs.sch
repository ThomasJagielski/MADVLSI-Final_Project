v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 5540 -120 5560 -120 { lab=#net30}
N 5500 -120 5540 -120 { lab=#net30}
N 5520 -120 5520 -30 { lab=#net30}
N 5410 -110 5410 -30 { lab=#net31}
N 5640 -130 5720 -130 { lab=Vflag}
N 5880 400 7530 400 { lab=Vflag}
N 7530 380 7530 400 { lab=Vflag}
N 7330 380 7330 400 { lab=Vflag}
N 7110 380 7110 400 { lab=Vflag}
N 6910 380 6910 400 { lab=Vflag}
N 6710 380 6710 400 { lab=Vflag}
N 6510 380 6510 400 { lab=Vflag}
N 6300 380 6300 400 { lab=Vflag}
N 6100 380 6100 400 { lab=Vflag}
N 6100 -260 6100 -240 { lab=#net32}
N 6130 -350 6160 -350 { lab=#net33}
N 6250 -300 6310 -300 { lab=Qn0}
N 6310 -440 6310 -300 { lab=Qn0}
N 6010 -440 6310 -440 { lab=Qn0}
N 6010 -440 6010 -350 { lab=Qn0}
N 6010 -350 6040 -350 { lab=Qn0}
N 6220 -260 6220 -240 { lab=#net34}
N 6220 -140 6220 -120 { lab=#net32}
N 6100 -120 6220 -120 { lab=#net32}
N 6500 -350 6530 -350 { lab=#net35}
N 6620 -300 6680 -300 { lab=Qn1}
N 6680 -440 6680 -300 { lab=Qn1}
N 6380 -440 6680 -440 { lab=Qn1}
N 6380 -440 6380 -350 { lab=Qn1}
N 6380 -350 6410 -350 { lab=Qn1}
N 6870 -350 6900 -350 { lab=#net36}
N 6990 -300 7050 -300 { lab=Qn2}
N 7050 -440 7050 -300 { lab=Qn2}
N 6750 -440 7050 -440 { lab=Qn2}
N 6750 -440 6750 -350 { lab=Qn2}
N 6750 -350 6780 -350 { lab=Qn2}
N 7240 -350 7270 -350 { lab=#net37}
N 7360 -300 7420 -300 { lab=Qn3}
N 7420 -440 7420 -300 { lab=Qn3}
N 7120 -440 7420 -440 { lab=Qn3}
N 7120 -440 7120 -350 { lab=Qn3}
N 7120 -350 7150 -350 { lab=Qn3}
N 6590 -260 6590 -120 { lab=Q0}
N 6310 -120 6590 -120 { lab=Q0}
N 6470 -160 6470 -120 { lab=Q0}
N 6960 -260 6960 -120 { lab=Q1}
N 6680 -120 6960 -120 { lab=Q1}
N 6840 -160 6840 -120 { lab=Q1}
N 7330 -260 7330 -120 { lab=Q2}
N 7050 -120 7330 -120 { lab=Q2}
N 7210 -160 7210 -120 { lab=Q2}
N 6150 -460 6150 -350 { lab=#net33}
N 6510 -460 6510 -350 { lab=#net35}
N 6870 -460 6870 -350 { lab=#net36}
N 7240 -460 7240 -350 { lab=#net37}
N 6100 -140 6100 -120 { lab=#net32}
N 6100 -240 6100 -140 { lab=#net32}
N 7610 -350 7640 -350 { lab=#net38}
N 7730 -300 7790 -300 { lab=Qn4}
N 7790 -440 7790 -300 { lab=Qn4}
N 7490 -440 7790 -440 { lab=Qn4}
N 7490 -440 7490 -350 { lab=Qn4}
N 7490 -350 7520 -350 { lab=Qn4}
N 7700 -260 7700 -120 { lab=Q3}
N 7420 -120 7700 -120 { lab=Q3}
N 7580 -160 7580 -120 { lab=Q3}
N 7610 -460 7610 -350 { lab=#net38}
N 7980 -350 8010 -350 { lab=#net39}
N 8100 -300 8160 -300 { lab=Qn5}
N 8160 -440 8160 -300 { lab=Qn5}
N 7860 -440 8160 -440 { lab=Qn5}
N 7860 -440 7860 -350 { lab=Qn5}
N 7860 -350 7890 -350 { lab=Qn5}
N 8350 -350 8380 -350 { lab=#net40}
N 8470 -300 8530 -300 { lab=Qn6}
N 8530 -440 8530 -300 { lab=Qn6}
N 8230 -440 8530 -440 { lab=Qn6}
N 8230 -440 8230 -350 { lab=Qn6}
N 8230 -350 8260 -350 { lab=Qn6}
N 8720 -350 8750 -350 { lab=#net41}
N 8840 -300 8900 -300 { lab=Qn7}
N 8900 -440 8900 -300 { lab=Qn7}
N 8600 -440 8900 -440 { lab=Qn7}
N 8600 -440 8600 -350 { lab=Qn7}
N 8600 -350 8630 -350 { lab=Qn7}
N 8070 -260 8070 -120 { lab=Q4}
N 7790 -120 8070 -120 { lab=Q4}
N 7950 -160 7950 -120 { lab=Q4}
N 8440 -260 8440 -120 { lab=Q5}
N 8160 -120 8440 -120 { lab=Q5}
N 8320 -160 8320 -120 { lab=Q5}
N 8810 -260 8810 -120 { lab=Q6}
N 8530 -120 8810 -120 { lab=Q6}
N 8690 -160 8690 -120 { lab=Q6}
N 7990 -460 7990 -350 { lab=#net39}
N 8350 -460 8350 -350 { lab=#net40}
N 8720 -460 8720 -350 { lab=#net41}
N 9080 -350 9110 -350 { lab=#net42}
N 9200 -300 9260 -300 { lab=Qn8}
N 9260 -440 9260 -300 { lab=Qn8}
N 8960 -440 9260 -440 { lab=Qn8}
N 8960 -440 8960 -350 { lab=Qn8}
N 8960 -350 8990 -350 { lab=Qn8}
N 9170 -260 9170 -120 { lab=Q7}
N 8890 -120 9170 -120 { lab=Q7}
N 9050 -160 9050 -120 { lab=Q7}
N 9080 -460 9080 -350 { lab=#net42}
N 5490 90 5520 90 { lab=#net30}
N 5520 -30 5520 90 { lab=#net30}
N 5410 -30 5410 90 { lab=#net31}
N 5410 90 5430 90 { lab=#net31}
N 5520 90 5550 90 { lab=#net30}
N 5410 -110 5420 -110 { lab=#net31}
N 5880 -140 5880 -100 { lab=#net43}
N 6010 -140 6010 -100 { lab=#net32}
N 5840 -170 5850 -170 { lab=#net44}
N 5840 -170 5840 -70 { lab=#net44}
N 5840 -70 5850 -70 { lab=#net44}
N 5970 -170 5980 -170 { lab=#net43}
N 5970 -170 5970 -70 { lab=#net43}
N 5970 -70 5980 -70 { lab=#net43}
N 5880 -120 5970 -120 { lab=#net43}
N 6010 -120 6100 -120 { lab=#net32}
N 5790 -120 5840 -120 { lab=#net44}
N 4730 -20 5070 -20 { lab=#net19}
C {devices/lab_pin.sym} 5420 -130 0 0 {name=l141 sig_type=std_logic lab=Vref_adc
}
C {devices/lab_pin.sym} 5670 -130 1 0 {name=l143 sig_type=std_logic lab=Vflag}
C {devices/lab_pin.sym} 5720 -110 0 0 {name=l144 sig_type=std_logic lab=adc_CLK}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/and2.sym} 5690 -120 0 0 {name=X38}
C {madvlsi/vdd.sym} 5750 -150 0 0 {name=l145 lab=VDD}
C {madvlsi/gnd.sym} 5750 -90 0 0 {name=l146 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 5990 320 0 0 {name=X39}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6190 320 0 0 {name=X40}
C {devices/lab_pin.sym} 5880 400 0 0 {name=l147 sig_type=std_logic lab=Vflag}
C {devices/lab_pin.sym} 6040 290 0 0 {name=l148 sig_type=std_logic lab=Q0}
C {devices/lab_pin.sym} 6240 290 0 0 {name=l149 sig_type=std_logic lab=Q1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6400 320 0 0 {name=X47}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6600 320 0 0 {name=X48}
C {devices/lab_pin.sym} 6450 290 0 0 {name=l150 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 6650 290 0 0 {name=l151 sig_type=std_logic lab=Q3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6800 320 0 0 {name=X49}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 7000 320 0 0 {name=X50}
C {devices/lab_pin.sym} 6850 290 0 0 {name=l152 sig_type=std_logic lab=Q4}
C {devices/lab_pin.sym} 7050 290 0 0 {name=l153 sig_type=std_logic lab=Q5}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 7220 320 0 0 {name=X51}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 7420 320 0 0 {name=X52}
C {devices/lab_pin.sym} 7270 290 0 0 {name=l154 sig_type=std_logic lab=Q6}
C {devices/lab_pin.sym} 7470 290 0 0 {name=l155 sig_type=std_logic lab=Q7}
C {devices/lab_pin.sym} 6130 290 2 0 {name=l156 sig_type=std_logic lab=Qout0}
C {devices/lab_pin.sym} 6330 290 2 0 {name=l157 sig_type=std_logic lab=Qout1}
C {devices/lab_pin.sym} 6540 290 2 0 {name=l158 sig_type=std_logic lab=Qout2}
C {devices/lab_pin.sym} 6740 290 2 0 {name=l159 sig_type=std_logic lab=Qout3}
C {devices/lab_pin.sym} 6940 290 2 0 {name=l160 sig_type=std_logic lab=Qout4}
C {devices/lab_pin.sym} 7140 290 2 0 {name=l161 sig_type=std_logic lab=Qout5}
C {devices/lab_pin.sym} 7360 290 2 0 {name=l162 sig_type=std_logic lab=Qout6}
C {devices/lab_pin.sym} 7560 290 2 0 {name=l163 sig_type=std_logic lab=Qout7}
C {devices/lab_pin.sym} 6150 -560 1 0 {name=l164 sig_type=std_logic lab=Q0}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 5990 -320 0 0 {name=X43}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6110 -320 0 0 {name=X44}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 6220 -180 3 0 {name=X45 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 6180 -180 3 0 {name=l165 lab=VDD}
C {madvlsi/gnd.sym} 6260 -180 3 0 {name=l166 lab=GND}
C {devices/lab_pin.sym} 6510 -560 1 0 {name=l167 sig_type=std_logic lab=Q1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6360 -320 0 0 {name=X46}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6480 -320 0 0 {name=X53}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 6470 -200 3 0 {name=X54 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 6430 -200 3 0 {name=l168 lab=VDD}
C {madvlsi/gnd.sym} 6510 -200 3 0 {name=l169 lab=GND}
C {devices/lab_pin.sym} 6310 -300 2 0 {name=l170 sig_type=std_logic lab=Qn0}
C {devices/lab_pin.sym} 6680 -300 2 0 {name=l171 sig_type=std_logic lab=Qn1}
C {devices/lab_pin.sym} 6870 -560 1 0 {name=l172 sig_type=std_logic lab=Q2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6730 -320 0 0 {name=X55}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6850 -320 0 0 {name=X56}
C {devices/lab_pin.sym} 7050 -300 2 0 {name=l173 sig_type=std_logic lab=Qn2}
C {devices/lab_pin.sym} 7240 -560 1 0 {name=l174 sig_type=std_logic lab=Q3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 7100 -320 0 0 {name=X57}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 7220 -320 0 0 {name=X58}
C {devices/lab_pin.sym} 7420 -300 2 0 {name=l175 sig_type=std_logic lab=Qn3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 6840 -200 3 0 {name=X61 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 6800 -200 3 0 {name=l176 lab=VDD}
C {madvlsi/gnd.sym} 6880 -200 3 0 {name=l177 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 7210 -200 3 0 {name=X62 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 7170 -200 3 0 {name=l178 lab=VDD}
C {madvlsi/gnd.sym} 7250 -200 3 0 {name=l179 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 6150 -500 3 0 {name=X64 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 6110 -500 3 0 {name=l180 lab=VDD}
C {madvlsi/gnd.sym} 6190 -500 3 0 {name=l181 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 6510 -500 3 0 {name=X65 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 6470 -500 3 0 {name=l182 lab=VDD}
C {madvlsi/gnd.sym} 6550 -500 3 0 {name=l183 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 6870 -500 3 0 {name=X66 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 6830 -500 3 0 {name=l184 lab=VDD}
C {madvlsi/gnd.sym} 6910 -500 3 0 {name=l185 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 7240 -500 3 0 {name=X67 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 7200 -500 3 0 {name=l186 lab=VDD}
C {madvlsi/gnd.sym} 7280 -500 3 0 {name=l187 lab=GND}
C {devices/lab_pin.sym} 6310 -120 0 0 {name=l188 sig_type=std_logic lab=Q0}
C {devices/lab_pin.sym} 6680 -120 0 0 {name=l189 sig_type=std_logic lab=Q1}
C {devices/lab_pin.sym} 7050 -120 0 0 {name=l190 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 7420 -120 0 0 {name=l191 sig_type=std_logic lab=Q3}
C {devices/lab_pin.sym} 6040 -320 0 0 {name=l192 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6040 -290 0 0 {name=l193 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6160 -290 0 0 {name=l194 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6160 -320 0 0 {name=l195 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6410 -320 0 0 {name=l196 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6410 -290 0 0 {name=l197 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6780 -320 0 0 {name=l198 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6780 -290 0 0 {name=l199 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 7150 -320 0 0 {name=l200 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 7150 -290 0 0 {name=l201 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6530 -290 0 0 {name=l202 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6530 -320 0 0 {name=l203 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6900 -290 0 0 {name=l204 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6900 -320 0 0 {name=l205 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 7270 -290 0 0 {name=l206 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 7270 -320 0 0 {name=l207 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 7610 -560 1 0 {name=l208 sig_type=std_logic lab=Q4}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 7470 -320 0 0 {name=X41}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 7590 -320 0 0 {name=X42}
C {devices/lab_pin.sym} 7790 -300 2 0 {name=l209 sig_type=std_logic lab=Qn4}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 7580 -200 3 0 {name=X59 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 7540 -200 3 0 {name=l210 lab=VDD}
C {madvlsi/gnd.sym} 7620 -200 3 0 {name=l211 lab=GND}
C {devices/lab_pin.sym} 7420 -120 0 0 {name=l212 sig_type=std_logic lab=Q3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 7610 -500 3 0 {name=X60 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 7570 -500 3 0 {name=l213 lab=VDD}
C {madvlsi/gnd.sym} 7650 -500 3 0 {name=l214 lab=GND}
C {devices/lab_pin.sym} 7520 -320 0 0 {name=l215 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 7520 -290 0 0 {name=l216 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 7640 -290 0 0 {name=l217 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 7640 -320 0 0 {name=l218 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 7990 -560 1 0 {name=l219 sig_type=std_logic lab=Q5}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 7840 -320 0 0 {name=X63}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 7960 -320 0 0 {name=X68}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 7950 -200 3 0 {name=X69 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 7910 -200 3 0 {name=l220 lab=VDD}
C {madvlsi/gnd.sym} 7990 -200 3 0 {name=l221 lab=GND}
C {devices/lab_pin.sym} 8160 -300 2 0 {name=l222 sig_type=std_logic lab=Qn5}
C {devices/lab_pin.sym} 8350 -560 1 0 {name=l223 sig_type=std_logic lab=Q6}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 8210 -320 0 0 {name=X70}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 8330 -320 0 0 {name=X71}
C {devices/lab_pin.sym} 8530 -300 2 0 {name=l224 sig_type=std_logic lab=Qn6}
C {devices/lab_pin.sym} 8720 -560 1 0 {name=l225 sig_type=std_logic lab=Q7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 8580 -320 0 0 {name=X72}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 8700 -320 0 0 {name=X73}
C {devices/lab_pin.sym} 8900 -300 2 0 {name=l226 sig_type=std_logic lab=Qn7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 8320 -200 3 0 {name=X74 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 8280 -200 3 0 {name=l227 lab=VDD}
C {madvlsi/gnd.sym} 8360 -200 3 0 {name=l228 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 8690 -200 3 0 {name=X75 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 8650 -200 3 0 {name=l229 lab=VDD}
C {madvlsi/gnd.sym} 8730 -200 3 0 {name=l230 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 7990 -500 3 0 {name=X76 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 7950 -500 3 0 {name=l231 lab=VDD}
C {madvlsi/gnd.sym} 8030 -500 3 0 {name=l232 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 8350 -500 3 0 {name=X77 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 8310 -500 3 0 {name=l233 lab=VDD}
C {madvlsi/gnd.sym} 8390 -500 3 0 {name=l234 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 8720 -500 3 0 {name=X78 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 8680 -500 3 0 {name=l235 lab=VDD}
C {madvlsi/gnd.sym} 8760 -500 3 0 {name=l236 lab=GND}
C {devices/lab_pin.sym} 7790 -120 0 0 {name=l237 sig_type=std_logic lab=Q4}
C {devices/lab_pin.sym} 8160 -120 0 0 {name=l238 sig_type=std_logic lab=Q5}
C {devices/lab_pin.sym} 8530 -120 0 0 {name=l239 sig_type=std_logic lab=Q6}
C {devices/lab_pin.sym} 7890 -320 0 0 {name=l240 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 7890 -290 0 0 {name=l241 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 8260 -320 0 0 {name=l242 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 8260 -290 0 0 {name=l243 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 8630 -320 0 0 {name=l244 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 8630 -290 0 0 {name=l245 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 8010 -290 0 0 {name=l246 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 8010 -320 0 0 {name=l247 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 8380 -290 0 0 {name=l248 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 8380 -320 0 0 {name=l249 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 8750 -290 0 0 {name=l250 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 8750 -320 0 0 {name=l251 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 9080 -560 1 0 {name=l252 sig_type=std_logic lab=Q8}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 8940 -320 0 0 {name=X79}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 9060 -320 0 0 {name=X80}
C {devices/lab_pin.sym} 9260 -300 2 0 {name=l253 sig_type=std_logic lab=Qn8}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 9050 -200 3 0 {name=X81 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 9010 -200 3 0 {name=l254 lab=VDD}
C {madvlsi/gnd.sym} 9090 -200 3 0 {name=l255 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 9080 -500 3 0 {name=X82 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 9040 -500 3 0 {name=l256 lab=VDD}
C {madvlsi/gnd.sym} 9120 -500 3 0 {name=l257 lab=GND}
C {devices/lab_pin.sym} 8890 -120 0 0 {name=l258 sig_type=std_logic lab=Q7}
C {devices/lab_pin.sym} 8990 -320 0 0 {name=l259 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 8990 -290 0 0 {name=l260 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 9110 -290 0 0 {name=l261 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 9110 -320 0 0 {name=l262 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6040 320 0 0 {name=l263 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6040 350 0 0 {name=l264 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6240 320 0 0 {name=l265 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6240 350 0 0 {name=l266 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6450 320 0 0 {name=l267 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6450 350 0 0 {name=l268 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6650 320 0 0 {name=l269 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6650 350 0 0 {name=l270 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6850 320 0 0 {name=l271 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6850 350 0 0 {name=l272 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 7050 320 0 0 {name=l273 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 7050 350 0 0 {name=l274 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 7270 320 0 0 {name=l275 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 7270 350 0 0 {name=l276 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 7470 320 0 0 {name=l277 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 7470 350 0 0 {name=l278 sig_type=std_logic lab=C}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 5460 90 0 0 {name=X83 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {devices/lab_pin.sym} 5470 110 3 0 {name=l279 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 5450 110 3 0 {name=l280 sig_type=std_logic lab=NP}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 5580 90 0 0 {name=X84 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {devices/lab_pin.sym} 5590 110 3 0 {name=l282 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 5570 110 3 0 {name=l283 sig_type=std_logic lab=NP}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage_lvs.sym} 5460 -120 0 0 {name=X85}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/comparator_lvs.sym} 5600 -130 0 0 {name=X86}
C {madvlsi/pmos3.sym} 5880 -170 0 0 {name=M25
L=0.15
W=2
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 5880 -200 0 0 {name=l284 lab=VDD}
C {madvlsi/nmos3.sym} 5880 -70 0 0 {name=M26
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 5880 -40 0 0 {name=l285 lab=GND}
C {madvlsi/pmos3.sym} 6010 -170 0 0 {name=M27
L=0.15
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 6010 -200 0 0 {name=l286 lab=VDD}
C {madvlsi/nmos3.sym} 6010 -70 0 0 {name=M28
L=0.15
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 6010 -40 0 0 {name=l287 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/mux2.sym} 5110 0 0 0 {name=X87}
C {devices/lab_pin.sym} 5110 40 3 0 {name=l288 sig_type=std_logic lab=Q8}
C {devices/lab_pin.sym} 5560 -140 0 0 {name=l140 sig_type=std_logic lab=Vref_adc
}
C {madvlsi/gnd.sym} 5070 20 1 0 {name=l142 lab=GND}
C {devices/lab_pin.sym} 5610 90 2 0 {name=l281 sig_type=std_logic lab=Vref_adc
}
