v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 690 -320 750 -320 { lab=#net1}
N 490 -240 490 -210 { lab=Vnn}
N 490 -150 490 -10 { lab=Vnn}
N 490 90 580 90 { lab=Vnn}
N 490 -10 490 90 { lab=Vnn}
N 740 -180 740 -10 { lab=#net1}
N 640 90 740 90 { lab=#net1}
N 740 -10 740 90 { lab=#net1}
N 190 -150 190 -80 { lab=#net2}
N 170 -150 210 -150 { lab=#net2}
N 70 -150 110 -150 { lab=Vn}
N 190 -20 190 30 { lab=Vref}
N 450 -150 490 -150 { lab=Vnn}
N 490 -210 490 -150 { lab=Vnn}
N 740 -320 740 -180 { lab=#net1}
N 490 -690 490 -520 { lab=Vpp}
N 490 -720 490 -690 { lab=Vpp}
N 130 -590 130 -530 { lab=net3}
N 110 -530 150 -530 { lab=net3}
N 10 -530 50 -530 { lab=Vp}
N 630 -690 690 -690 { lab=Vref}
N 490 -820 490 -780 { lab=Vref}
N 130 -690 130 -650 { lab=Vref}
N 490 -290 490 -240 { lab=Vnn}
N 490 -520 490 -350 { lab=Vpp}
N 490 -310 490 -290 { lab=Vnn}
N 490 -350 490 -330 { lab=Vpp}
N 670 -320 690 -320 { lab=#net1}
N 490 -310 590 -310 { lab=Vnn}
N 490 -330 590 -330 { lab=Vpp}
N 750 -320 800 -320 { lab=#net1}
N 800 -320 890 -320 { lab=#net1}
N 490 -690 510 -690 { lab=Vpp}
N 630 -70 740 -70 { lab=#net1}
N 490 -70 570 -70 { lab=Vnn}
N 490 -180 570 -180 { lab=Vnn}
N 630 -180 740 -180 { lab=#net1}
N 570 -690 570 -630 { lab=Vpp}
N 510 -690 570 -690 { lab=Vpp}
N 630 -690 630 -630 { lab=Vref}
N 390 -180 390 290 { lab=Vnn}
N 330 -180 330 290 { lab=#net2}
N 390 -150 450 -150 { lab=Vnn}
N 210 -150 330 -150 { lab=#net2}
N 320 -1000 320 -530 { lab=Vpp}
N 260 -1000 260 -530 { lab=net3}
N 320 -530 490 -530 { lab=Vpp}
N 150 -530 260 -530 { lab=net3}
N 890 -320 890 -230 { lab=#net1}
N 770 1390 830 1390 { lab=#net4}
N 570 1470 570 1500 { lab=#net5}
N 570 1560 570 1700 { lab=#net5}
N 570 1800 660 1800 { lab=#net5}
N 570 1700 570 1800 { lab=#net5}
N 820 1530 820 1700 { lab=#net4}
N 720 1800 820 1800 { lab=#net4}
N 820 1700 820 1800 { lab=#net4}
N 270 1560 270 1630 { lab=#net6}
N 250 1560 290 1560 { lab=#net6}
N 150 1560 190 1560 { lab=Vn}
N 270 1690 270 1740 { lab=Vref}
N 530 1560 570 1560 { lab=#net5}
N 570 1500 570 1560 { lab=#net5}
N 820 1390 820 1530 { lab=#net4}
N 570 1020 570 1190 { lab=net7}
N 570 990 570 1020 { lab=net7}
N 210 1120 210 1180 { lab=net8}
N 190 1180 230 1180 { lab=net8}
N 90 1180 130 1180 { lab=Vp}
N 710 1020 770 1020 { lab=Vref}
N 570 890 570 930 { lab=Vref}
N 210 1020 210 1060 { lab=Vref}
N 570 1420 570 1470 { lab=#net5}
N 570 1190 570 1360 { lab=net7}
N 570 1400 570 1420 { lab=#net5}
N 570 1360 570 1380 { lab=net7}
N 750 1390 770 1390 { lab=#net4}
N 570 1400 670 1400 { lab=#net5}
N 570 1380 670 1380 { lab=net7}
N 830 1390 880 1390 { lab=#net4}
N 880 1390 970 1390 { lab=#net4}
N 570 1020 590 1020 { lab=net7}
N 710 1640 820 1640 { lab=#net4}
N 570 1640 650 1640 { lab=#net5}
N 570 1530 650 1530 { lab=#net5}
N 710 1530 820 1530 { lab=#net4}
N 650 1020 650 1080 { lab=net7}
N 590 1020 650 1020 { lab=net7}
N 710 1020 710 1080 { lab=Vref}
N 470 1530 470 2000 { lab=#net5}
N 410 1530 410 2000 { lab=#net6}
N 470 1560 530 1560 { lab=#net5}
N 290 1560 410 1560 { lab=#net6}
N 400 710 400 1180 { lab=net7}
N 340 710 340 1180 { lab=net8}
N 400 1180 570 1180 { lab=net7}
N 230 1180 340 1180 { lab=net8}
N 970 1390 970 1480 { lab=#net4}
N 970 1540 970 1620 { lab=#net9}
N 2720 -500 2780 -500 { lab=#net10}
N 2520 -420 2520 -390 { lab=#net11}
N 2520 -330 2520 -190 { lab=#net11}
N 2520 -90 2610 -90 { lab=#net11}
N 2520 -190 2520 -90 { lab=#net11}
N 2770 -360 2770 -190 { lab=#net10}
N 2670 -90 2770 -90 { lab=#net10}
N 2770 -190 2770 -90 { lab=#net10}
N 2220 -330 2220 -260 { lab=#net12}
N 2200 -330 2240 -330 { lab=#net12}
N 2100 -330 2140 -330 { lab=Vn}
N 2220 -200 2220 -150 { lab=Vouts}
N 2480 -330 2520 -330 { lab=#net11}
N 2520 -390 2520 -330 { lab=#net11}
N 2770 -500 2770 -360 { lab=#net10}
N 2520 -870 2520 -700 { lab=#net13}
N 2520 -900 2520 -870 { lab=#net13}
N 2160 -770 2160 -710 { lab=#net14}
N 2140 -710 2180 -710 { lab=#net14}
N 2040 -710 2080 -710 { lab=Vp}
N 2660 -870 2720 -870 { lab=Vouts}
N 2520 -1000 2520 -960 { lab=Vouts}
N 2160 -870 2160 -830 { lab=Vouts}
N 2520 -470 2520 -420 { lab=#net11}
N 2520 -700 2520 -530 { lab=#net13}
N 2520 -490 2520 -470 { lab=#net11}
N 2520 -530 2520 -510 { lab=#net13}
N 2700 -500 2720 -500 { lab=#net10}
N 2520 -490 2620 -490 { lab=#net11}
N 2520 -510 2620 -510 { lab=#net13}
N 2780 -500 2830 -500 { lab=#net10}
N 2830 -500 2920 -500 { lab=#net10}
N 2520 -870 2540 -870 { lab=#net13}
N 2660 -250 2770 -250 { lab=#net10}
N 2520 -250 2600 -250 { lab=#net11}
N 2520 -360 2600 -360 { lab=#net11}
N 2660 -360 2770 -360 { lab=#net10}
N 2600 -870 2600 -810 { lab=#net13}
N 2540 -870 2600 -870 { lab=#net13}
N 2660 -870 2660 -810 { lab=Vouts}
N 2420 -360 2420 110 { lab=#net11}
N 2360 -360 2360 110 { lab=#net12}
N 2420 -330 2480 -330 { lab=#net11}
N 2240 -330 2360 -330 { lab=#net12}
N 2350 -1180 2350 -710 { lab=#net13}
N 2290 -1180 2290 -710 { lab=#net14}
N 2350 -710 2520 -710 { lab=#net13}
N 2180 -710 2290 -710 { lab=#net14}
N 2920 -500 2920 -410 { lab=#net10}
N 2800 1210 2860 1210 { lab=#net15}
N 2600 1290 2600 1320 { lab=#net16}
N 2600 1380 2600 1520 { lab=#net16}
N 2600 1620 2690 1620 { lab=#net16}
N 2600 1520 2600 1620 { lab=#net16}
N 2850 1350 2850 1520 { lab=#net15}
N 2750 1620 2850 1620 { lab=#net15}
N 2850 1520 2850 1620 { lab=#net15}
N 2300 1380 2300 1450 { lab=#net17}
N 2280 1380 2320 1380 { lab=#net17}
N 2180 1380 2220 1380 { lab=Vn}
N 2300 1510 2300 1560 { lab=Vouts}
N 2560 1380 2600 1380 { lab=#net16}
N 2600 1320 2600 1380 { lab=#net16}
N 2850 1210 2850 1350 { lab=#net15}
N 2600 840 2600 1010 { lab=#net18}
N 2600 810 2600 840 { lab=#net18}
N 2240 940 2240 1000 { lab=#net19}
N 2220 1000 2260 1000 { lab=#net19}
N 2120 1000 2160 1000 { lab=Vp}
N 2740 840 2800 840 { lab=Vouts}
N 2600 710 2600 750 { lab=Vouts}
N 2240 840 2240 880 { lab=Vouts}
N 2600 1240 2600 1290 { lab=#net16}
N 2600 1010 2600 1180 { lab=#net18}
N 2600 1220 2600 1240 { lab=#net16}
N 2600 1180 2600 1200 { lab=#net18}
N 2780 1210 2800 1210 { lab=#net15}
N 2600 1220 2700 1220 { lab=#net16}
N 2600 1200 2700 1200 { lab=#net18}
N 2860 1210 2910 1210 { lab=#net15}
N 2910 1210 3000 1210 { lab=#net15}
N 2600 840 2620 840 { lab=#net18}
N 2740 1460 2850 1460 { lab=#net15}
N 2600 1460 2680 1460 { lab=#net16}
N 2600 1350 2680 1350 { lab=#net16}
N 2740 1350 2850 1350 { lab=#net15}
N 2680 840 2680 900 { lab=#net18}
N 2620 840 2680 840 { lab=#net18}
N 2740 840 2740 900 { lab=Vouts}
N 2500 1350 2500 1820 { lab=#net16}
N 2440 1350 2440 1820 { lab=#net17}
N 2500 1380 2560 1380 { lab=#net16}
N 2320 1380 2440 1380 { lab=#net17}
N 2430 530 2430 1000 { lab=#net18}
N 2370 530 2370 1000 { lab=#net19}
N 2430 1000 2600 1000 { lab=#net18}
N 2260 1000 2370 1000 { lab=#net19}
N 3000 1210 3000 1300 { lab=#net15}
N 970 1620 1080 1620 { lab=#net9}
N 1080 -80 1080 1620 { lab=#net9}
N 890 -80 1080 -80 { lab=#net9}
N 890 -170 890 -80 { lab=#net9}
N 3000 1360 3000 1440 { lab=#net20}
N 3000 1440 3110 1440 { lab=#net20}
N 3110 -260 3110 1440 { lab=#net20}
N 2920 -260 3110 -260 { lab=#net20}
N 2920 -350 2920 -260 { lab=#net20}
N 1860 490 1860 540 { lab=Vouts}
N 1780 500 1780 540 { lab=#net21}
N 1760 480 1780 480 { lab=#net22}
N 1780 540 1780 580 { lab=#net21}
N 1780 470 1780 480 { lab=#net22}
N 1780 580 1780 920 { lab=#net21}
N 1780 920 1860 920 { lab=#net21}
N 1860 900 1860 920 { lab=#net21}
N 1840 570 1840 870 { lab=GND}
N 1760 140 1760 440 { lab=GND}
N 1770 920 1780 920 { lab=#net21}
N 1310 550 1730 550 { lab=GND}
N 1280 920 1710 920 { lab=GND}
N 1760 570 1780 570 { lab=#net21}
N 1310 460 1730 460 { lab=GND}
N 1280 570 1280 920 { lab=GND}
N 1770 1050 1780 1050 { lab=#net21}
N 1780 920 1780 1050 { lab=#net21}
N 1690 1050 1710 1050 { lab=GND}
N 1690 920 1690 1050 { lab=GND}
N 1080 480 1280 480 { lab=#net9}
N 940 60 940 530 { lab=#net9}
N 880 60 880 530 { lab=GND}
N 940 660 940 1130 { lab=#net9}
N 880 660 880 1130 { lab=GND}
N 940 850 1080 850 { lab=#net9}
N 940 350 1080 350 { lab=#net9}
N 840 320 880 320 { lab=GND}
N 840 660 880 660 { lab=GND}
N 400 710 400 1180 { lab=net7}
N 340 710 340 1180 { lab=net8}
N 650 390 650 450 { lab=#net23}
N 710 390 710 450 { lab=#net24}
N 650 570 650 630 { lab=#net25}
N 710 570 710 630 { lab=#net26}
N 2590 250 2590 310 { lab=#net27}
N 2650 250 2650 310 { lab=#net28}
N 2590 430 2590 490 { lab=#net29}
N 2650 430 2650 490 { lab=#net30}
N 3000 0 3000 470 { lab=#net20}
N 2940 0 2940 470 { lab=GND}
N 3000 600 3000 1070 { lab=#net20}
N 2940 600 2940 1070 { lab=GND}
N 2900 260 2940 260 { lab=GND}
N 2900 600 2940 600 { lab=GND}
N 3000 840 3110 840 { lab=#net20}
N 3000 250 3110 250 { lab=#net20}
C {devices/lab_pin.sym} 490 -390 0 0 {name=l6 sig_type=std_logic lab=Vpp}
C {devices/lab_pin.sym} 490 -240 0 0 {name=l13 sig_type=std_logic lab=Vnn}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 140 -150 0 0 {name=X10}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 190 -50 3 0 {name=X11}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 610 90 0 0 {name=X12}
C {devices/lab_pin.sym} 190 30 3 0 {name=l1 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 600 110 3 0 {name=l31 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 620 110 3 0 {name=l32 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 130 -130 3 0 {name=l33 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 150 -130 3 0 {name=l50 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 210 -40 2 0 {name=l51 sig_type=std_logic lab=Vphi2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 80 -530 0 0 {name=X5}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 130 -620 1 0 {name=X7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 490 -750 1 0 {name=X9}
C {devices/lab_pin.sym} 490 -820 1 0 {name=l36 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 130 -690 1 0 {name=l38 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 70 -510 3 0 {name=l44 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 90 -510 3 0 {name=l49 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 110 -630 0 0 {name=l52 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 110 -610 0 0 {name=l53 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 690 -690 2 0 {name=l54 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 210 -60 2 0 {name=l34 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 10 -530 1 0 {name=l35 sig_type=std_logic lab=Vp}
C {devices/lab_pin.sym} 70 -150 1 0 {name=l37 sig_type=std_logic lab=Vn}
C {devices/lab_pin.sym} 470 -760 0 0 {name=l39 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 470 -740 0 0 {name=l40 sig_type=std_logic lab=Vnphi1}
C {sky130_fd_pr/cap_mim_m3_1.sym} 600 -630 3 0 {name=C1 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage_lvs.sym} 630 -320 0 0 {name=X1}
C {sky130_fd_pr/cap_mim_m3_1.sym} 600 -690 3 0 {name=C3 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 600 -180 3 0 {name=C4 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 600 -70 3 0 {name=C6 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 360 -150 1 0 {name=C5 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 360 -180 1 0 {name=C7 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 360 -80 1 0 {name=C8 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 360 -110 1 0 {name=C9 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 360 -20 1 0 {name=C10 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 360 -50 1 0 {name=C11 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 360 40 1 0 {name=C12 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 360 10 1 0 {name=C13 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 360 110 1 0 {name=C14 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 360 80 1 0 {name=C15 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 360 170 1 0 {name=C16 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 360 140 1 0 {name=C17 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 360 230 1 0 {name=C18 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 360 200 1 0 {name=C19 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 360 290 1 0 {name=C20 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 360 260 1 0 {name=C21 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 290 -970 1 0 {name=C22 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 290 -1000 1 0 {name=C23 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 290 -900 1 0 {name=C24 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 290 -930 1 0 {name=C25 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 290 -840 1 0 {name=C26 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 290 -870 1 0 {name=C27 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 290 -780 1 0 {name=C28 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 290 -810 1 0 {name=C29 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 290 -710 1 0 {name=C30 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 290 -740 1 0 {name=C31 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 290 -650 1 0 {name=C32 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 290 -680 1 0 {name=C33 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 290 -590 1 0 {name=C34 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 290 -620 1 0 {name=C35 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 290 -530 1 0 {name=C36 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 290 -560 1 0 {name=C37 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 890 -200 1 0 {name=X20}
C {devices/lab_pin.sym} 870 -210 0 0 {name=l70 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 870 -190 0 0 {name=l71 sig_type=std_logic lab=Vnphi2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 220 1560 0 0 {name=X2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 270 1660 3 0 {name=X3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 690 1800 0 0 {name=X4}
C {devices/lab_pin.sym} 270 1740 3 0 {name=l4 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 680 1820 3 0 {name=l5 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 700 1820 3 0 {name=l7 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 210 1580 3 0 {name=l8 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 230 1580 3 0 {name=l9 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 290 1670 2 0 {name=l10 sig_type=std_logic lab=Vphi1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 160 1180 0 0 {name=X6}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 210 1090 1 0 {name=X8}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 570 960 1 0 {name=X13}
C {devices/lab_pin.sym} 570 890 1 0 {name=l11 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 210 1020 1 0 {name=l12 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 150 1200 3 0 {name=l14 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 170 1200 3 0 {name=l15 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 190 1080 0 0 {name=l16 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 190 1100 0 0 {name=l17 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 770 1020 2 0 {name=l18 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 290 1650 2 0 {name=l19 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 90 1180 1 0 {name=l20 sig_type=std_logic lab=Vp}
C {devices/lab_pin.sym} 150 1560 1 0 {name=l21 sig_type=std_logic lab=Vn}
C {devices/lab_pin.sym} 550 950 0 0 {name=l22 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 550 970 0 0 {name=l23 sig_type=std_logic lab=Vnphi2}
C {sky130_fd_pr/cap_mim_m3_1.sym} 680 1080 3 0 {name=C2 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage_lvs.sym} 710 1390 0 0 {name=X14}
C {sky130_fd_pr/cap_mim_m3_1.sym} 680 1020 3 0 {name=C38 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 680 1530 3 0 {name=C39 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 680 1640 3 0 {name=C40 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 440 1560 1 0 {name=C41 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 440 1530 1 0 {name=C42 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 440 1630 1 0 {name=C43 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 440 1600 1 0 {name=C44 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 440 1690 1 0 {name=C45 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 440 1660 1 0 {name=C46 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 440 1750 1 0 {name=C47 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 440 1720 1 0 {name=C48 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 440 1820 1 0 {name=C49 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 440 1790 1 0 {name=C50 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 440 1880 1 0 {name=C51 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 440 1850 1 0 {name=C52 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 440 1940 1 0 {name=C53 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 440 1910 1 0 {name=C54 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 440 2000 1 0 {name=C55 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 440 1970 1 0 {name=C56 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 740 1 0 {name=C57 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 710 1 0 {name=C58 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 810 1 0 {name=C59 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 780 1 0 {name=C60 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 870 1 0 {name=C61 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 840 1 0 {name=C62 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 930 1 0 {name=C63 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 900 1 0 {name=C64 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 1000 1 0 {name=C65 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 970 1 0 {name=C66 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 1060 1 0 {name=C67 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 1030 1 0 {name=C68 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 1120 1 0 {name=C69 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 1090 1 0 {name=C70 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 1180 1 0 {name=C71 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 1150 1 0 {name=C72 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 970 1510 1 0 {name=X15}
C {devices/lab_pin.sym} 950 1500 0 0 {name=l24 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 950 1520 0 0 {name=l25 sig_type=std_logic lab=Vnphi1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2170 -330 0 0 {name=X16}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2220 -230 3 0 {name=X17}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2640 -90 0 0 {name=X18}
C {devices/lab_pin.sym} 2630 -70 3 0 {name=l27 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 2650 -70 3 0 {name=l28 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 2160 -310 3 0 {name=l29 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 2180 -310 3 0 {name=l30 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 2240 -220 2 0 {name=l41 sig_type=std_logic lab=Vphi2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2110 -710 0 0 {name=X19}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2160 -800 1 0 {name=X21}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2520 -930 1 0 {name=X22}
C {devices/lab_pin.sym} 2100 -690 3 0 {name=l45 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 2120 -690 3 0 {name=l46 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 2140 -810 0 0 {name=l47 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 2140 -790 0 0 {name=l48 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 2240 -240 2 0 {name=l56 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 2040 -710 1 0 {name=l57 sig_type=std_logic lab=Vp}
C {devices/lab_pin.sym} 2100 -330 1 0 {name=l58 sig_type=std_logic lab=Vn}
C {devices/lab_pin.sym} 2500 -940 0 0 {name=l59 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 2500 -920 0 0 {name=l60 sig_type=std_logic lab=Vnphi1}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2630 -810 3 0 {name=C73 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage_lvs.sym} 2660 -500 0 0 {name=X23}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2630 -870 3 0 {name=C74 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2630 -360 3 0 {name=C75 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2630 -250 3 0 {name=C76 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 -330 1 0 {name=C77 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 -360 1 0 {name=C78 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 -260 1 0 {name=C79 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 -290 1 0 {name=C80 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 -200 1 0 {name=C81 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 -230 1 0 {name=C82 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 -140 1 0 {name=C83 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 -170 1 0 {name=C84 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 -70 1 0 {name=C85 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 -100 1 0 {name=C86 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 -10 1 0 {name=C87 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 -40 1 0 {name=C88 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 50 1 0 {name=C89 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 20 1 0 {name=C90 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 110 1 0 {name=C91 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 80 1 0 {name=C92 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2320 -1150 1 0 {name=C93 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2320 -1180 1 0 {name=C94 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2320 -1080 1 0 {name=C95 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2320 -1110 1 0 {name=C96 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2320 -1020 1 0 {name=C97 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2320 -1050 1 0 {name=C98 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2320 -960 1 0 {name=C99 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2320 -990 1 0 {name=C100 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2320 -890 1 0 {name=C101 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2320 -920 1 0 {name=C102 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2320 -830 1 0 {name=C103 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2320 -860 1 0 {name=C104 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2320 -770 1 0 {name=C105 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2320 -800 1 0 {name=C106 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2320 -710 1 0 {name=C107 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2320 -740 1 0 {name=C108 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2920 -380 1 0 {name=X24}
C {devices/lab_pin.sym} 2900 -390 0 0 {name=l61 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 2900 -370 0 0 {name=l62 sig_type=std_logic lab=Vnphi2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2250 1380 0 0 {name=X25}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2300 1480 3 0 {name=X26}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2720 1620 0 0 {name=X27}
C {devices/lab_pin.sym} 2710 1640 3 0 {name=l64 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 2730 1640 3 0 {name=l65 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 2240 1400 3 0 {name=l66 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 2260 1400 3 0 {name=l67 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 2320 1490 2 0 {name=l68 sig_type=std_logic lab=Vphi1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2190 1000 0 0 {name=X28}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2240 910 1 0 {name=X29}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2600 780 1 0 {name=X30}
C {devices/lab_pin.sym} 2180 1020 3 0 {name=l73 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 2200 1020 3 0 {name=l74 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 2220 900 0 0 {name=l75 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 2220 920 0 0 {name=l76 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 2320 1470 2 0 {name=l78 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 2120 1000 1 0 {name=l79 sig_type=std_logic lab=Vp}
C {devices/lab_pin.sym} 2180 1380 1 0 {name=l80 sig_type=std_logic lab=Vn}
C {devices/lab_pin.sym} 2580 770 0 0 {name=l81 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 2580 790 0 0 {name=l82 sig_type=std_logic lab=Vnphi2}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2710 900 3 0 {name=C109 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage_lvs.sym} 2740 1210 0 0 {name=X31}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2710 840 3 0 {name=C110 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2710 1350 3 0 {name=C111 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2710 1460 3 0 {name=C112 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2470 1380 1 0 {name=C113 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2470 1350 1 0 {name=C114 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2470 1450 1 0 {name=C115 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2470 1420 1 0 {name=C116 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2470 1510 1 0 {name=C117 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2470 1480 1 0 {name=C118 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2470 1570 1 0 {name=C119 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2470 1540 1 0 {name=C120 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2470 1640 1 0 {name=C121 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2470 1610 1 0 {name=C122 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2470 1700 1 0 {name=C123 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2470 1670 1 0 {name=C124 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2470 1760 1 0 {name=C125 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2470 1730 1 0 {name=C126 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2470 1820 1 0 {name=C127 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2470 1790 1 0 {name=C128 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2400 560 1 0 {name=C129 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2400 530 1 0 {name=C130 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2400 630 1 0 {name=C131 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2400 600 1 0 {name=C132 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2400 690 1 0 {name=C133 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2400 660 1 0 {name=C134 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2400 750 1 0 {name=C135 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2400 720 1 0 {name=C136 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2400 820 1 0 {name=C137 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2400 790 1 0 {name=C138 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2400 880 1 0 {name=C139 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2400 850 1 0 {name=C140 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2400 940 1 0 {name=C141 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2400 910 1 0 {name=C142 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2400 1000 1 0 {name=C143 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2400 970 1 0 {name=C144 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 3000 1330 1 0 {name=X32}
C {devices/lab_pin.sym} 2980 1320 0 0 {name=l83 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 2980 1340 0 0 {name=l84 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 1860 490 2 0 {name=l2 sig_type=std_logic lab=Vouts}
C {madvlsi/gnd.sym} 1280 570 1 1 {name=l3 lab=GND}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1740 1050 1 0 {name=C145 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage_lvs.sym} 1820 490 0 0 {name=X33}
C {sky130_fd_pr/res_xhigh_po.sym} 1860 570 0 0 {name=R1
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1730 570 1 0 {name=R4
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1860 630 0 0 {name=R5
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1860 690 0 0 {name=R6
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1860 750 0 0 {name=R7
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1860 810 0 0 {name=R8
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1860 870 0 0 {name=R9
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 1840 870 1 1 {name=l85 lab=GND}
C {sky130_fd_pr/res_xhigh_po.sym} 1780 140 0 0 {name=R10
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1780 200 0 0 {name=R11
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1780 260 0 0 {name=R12
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1780 320 0 0 {name=R13
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1780 380 0 0 {name=R14
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1780 440 0 0 {name=R15
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 1760 140 1 1 {name=l86 lab=GND}
C {madvlsi/gnd.sym} 1780 110 2 1 {name=l87 lab=GND}
C {sky130_fd_pr/res_xhigh_po.sym} 1670 570 1 0 {name=R2
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1610 570 1 0 {name=R16
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1550 570 1 0 {name=R17
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1490 570 1 0 {name=R18
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1430 570 1 0 {name=R19
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1370 570 1 0 {name=R20
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1310 570 1 0 {name=R21
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 1310 550 2 1 {name=l88 lab=GND}
C {sky130_fd_pr/res_xhigh_po.sym} 1730 480 1 0 {name=R3
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1670 480 1 0 {name=R22
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1610 480 1 0 {name=R23
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1550 480 1 0 {name=R24
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1490 480 1 0 {name=R25
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1430 480 1 0 {name=R26
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1370 480 1 0 {name=R27
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1310 480 1 0 {name=R28
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 1310 460 2 1 {name=l89 lab=GND}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1740 920 1 0 {name=C146 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 90 1 0 {name=C147 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 60 1 0 {name=C148 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 160 1 0 {name=C149 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 130 1 0 {name=C150 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 220 1 0 {name=C151 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 190 1 0 {name=C152 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 280 1 0 {name=C153 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 250 1 0 {name=C154 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 350 1 0 {name=C155 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 320 1 0 {name=C156 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 410 1 0 {name=C157 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 380 1 0 {name=C158 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 470 1 0 {name=C159 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 440 1 0 {name=C160 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 530 1 0 {name=C161 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 500 1 0 {name=C162 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 690 1 0 {name=C163 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 660 1 0 {name=C164 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 760 1 0 {name=C165 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 730 1 0 {name=C166 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 820 1 0 {name=C167 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 790 1 0 {name=C168 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 880 1 0 {name=C169 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 850 1 0 {name=C170 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 950 1 0 {name=C171 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 920 1 0 {name=C172 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 1010 1 0 {name=C173 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 980 1 0 {name=C174 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 1070 1 0 {name=C175 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 1040 1 0 {name=C176 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 1130 1 0 {name=C177 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 1100 1 0 {name=C178 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {madvlsi/gnd.sym} 840 320 1 1 {name=l90 lab=GND}
C {madvlsi/gnd.sym} 840 660 1 1 {name=l91 lab=GND}
C {devices/lab_pin.sym} 2600 710 1 0 {name=l26 sig_type=std_logic lab=Vouts}
C {devices/lab_pin.sym} 2240 840 1 0 {name=l42 sig_type=std_logic lab=Vouts}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 740 1 0 {name=C179 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 710 1 0 {name=C180 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 810 1 0 {name=C181 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 780 1 0 {name=C182 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 870 1 0 {name=C183 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 840 1 0 {name=C184 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 930 1 0 {name=C185 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 900 1 0 {name=C186 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 1000 1 0 {name=C187 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 970 1 0 {name=C188 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 1060 1 0 {name=C189 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 1030 1 0 {name=C190 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 1120 1 0 {name=C191 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 1090 1 0 {name=C192 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 1180 1 0 {name=C193 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 1150 1 0 {name=C194 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2300 1560 3 0 {name=l43 sig_type=std_logic lab=Vouts}
C {devices/lab_pin.sym} 2220 -150 3 0 {name=l55 sig_type=std_logic lab=Vouts}
C {devices/lab_pin.sym} 2160 -870 1 0 {name=l63 sig_type=std_logic lab=Vouts}
C {devices/lab_pin.sym} 2520 -1000 1 0 {name=l69 sig_type=std_logic lab=Vouts}
C {sky130_fd_pr/cap_mim_m3_1.sym} 680 450 3 0 {name=C195 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 680 390 3 0 {name=C196 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 680 630 3 0 {name=C197 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 680 570 3 0 {name=C198 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2620 310 3 0 {name=C199 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2620 250 3 0 {name=C200 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2620 490 3 0 {name=C201 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2620 430 3 0 {name=C202 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 30 1 0 {name=C203 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 0 1 0 {name=C204 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 100 1 0 {name=C205 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 70 1 0 {name=C206 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 160 1 0 {name=C207 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 130 1 0 {name=C208 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 220 1 0 {name=C209 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 190 1 0 {name=C210 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 290 1 0 {name=C211 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 260 1 0 {name=C212 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 350 1 0 {name=C213 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 320 1 0 {name=C214 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 410 1 0 {name=C215 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 380 1 0 {name=C216 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 470 1 0 {name=C217 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 440 1 0 {name=C218 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 630 1 0 {name=C219 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 600 1 0 {name=C220 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 700 1 0 {name=C221 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 670 1 0 {name=C222 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 760 1 0 {name=C223 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 730 1 0 {name=C224 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 820 1 0 {name=C225 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 790 1 0 {name=C226 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 890 1 0 {name=C227 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 860 1 0 {name=C228 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 950 1 0 {name=C229 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 920 1 0 {name=C230 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 1010 1 0 {name=C231 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 980 1 0 {name=C232 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 1070 1 0 {name=C233 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 1040 1 0 {name=C234 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {madvlsi/gnd.sym} 2900 260 1 1 {name=l98 lab=GND}
C {madvlsi/gnd.sym} 2900 600 1 1 {name=l99 lab=GND}
C {devices/lab_pin.sym} 2800 840 2 0 {name=l100 sig_type=std_logic lab=Vouts}
C {devices/lab_pin.sym} 2720 -870 2 0 {name=l72 sig_type=std_logic lab=Vouts}
C {devices/lab_pin.sym} 570 1310 0 0 {name=l77 sig_type=std_logic lab=net7}
C {devices/lab_pin.sym} 280 1180 1 0 {name=l92 sig_type=std_logic lab=net8}
C {devices/lab_pin.sym} 190 -530 1 0 {name=l93 sig_type=std_logic lab=net3}
