v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
L 4 3860 230 3860 860 {}
L 4 -100 1280 -100 1410 {}
L 4 -100 1410 70 1410 {}
L 4 70 1280 70 1410 {}
L 4 -100 1280 70 1280 {}
L 4 -300 1300 -300 1400 {}
L 4 -300 1400 -120 1400 {}
L 4 -120 1290 -120 1400 {}
L 4 -300 1290 -120 1290 {}
L 4 -300 1290 -300 1310 {}
L 4 200 1280 200 1410 {}
L 4 200 1410 370 1410 {}
L 4 370 1280 370 1410 {}
L 4 200 1280 370 1280 {}
L 4 400 1280 400 1410 {}
L 4 400 1410 570 1410 {}
L 4 570 1280 570 1410 {}
L 4 400 1280 570 1280 {}
L 4 700 1280 700 1410 {}
L 4 700 1410 870 1410 {}
L 4 870 1280 870 1410 {}
L 4 700 1280 870 1280 {}
L 4 900 1280 900 1410 {}
L 4 900 1410 1070 1410 {}
L 4 1070 1280 1070 1410 {}
L 4 900 1280 1070 1280 {}
L 4 2420 1910 2420 2040 {}
L 4 2420 2040 2590 2040 {}
L 4 2590 1910 2590 2040 {}
L 4 2420 1910 2590 1910 {}
L 4 2220 1930 2220 2030 {}
L 4 2220 2030 2400 2030 {}
L 4 2400 1920 2400 2030 {}
L 4 2220 1920 2400 1920 {}
L 4 2220 1920 2220 1940 {}
L 4 2720 1910 2720 2040 {}
L 4 2720 2040 2890 2040 {}
L 4 2890 1910 2890 2040 {}
L 4 2720 1910 2890 1910 {}
L 4 2920 1910 2920 2040 {}
L 4 2920 2040 3090 2040 {}
L 4 3090 1910 3090 2040 {}
L 4 2920 1910 3090 1910 {}
L 4 3220 1910 3220 2040 {}
L 4 3220 2040 3390 2040 {}
L 4 3390 1910 3390 2040 {}
L 4 3220 1910 3390 1910 {}
L 4 3420 1910 3420 2040 {}
L 4 3420 2040 3590 2040 {}
L 4 3590 1910 3590 2040 {}
L 4 3420 1910 3590 1910 {}
L 4 1230 80 1430 80 {}
L 4 1430 -90 1430 80 {}
L 4 1230 -90 1430 -90 {}
L 4 1230 -90 1230 80 {}
L 4 980 80 1180 80 {}
L 4 1180 -90 1180 80 {}
L 4 980 -90 1180 -90 {}
L 4 980 -90 980 80 {}
L 4 640 80 840 80 {}
L 4 840 -90 840 80 {}
L 4 640 -90 840 -90 {}
L 4 640 -90 640 80 {}
L 4 1710 540 1910 540 {}
L 4 1910 370 1910 540 {}
L 4 1710 370 1910 370 {}
L 4 1710 370 1710 540 {}
L 4 1460 540 1660 540 {}
L 4 1660 370 1660 540 {}
L 4 1460 370 1660 370 {}
L 4 1460 370 1460 540 {}
L 4 510 390 510 540 {}
L 4 510 540 950 540 {}
L 4 950 390 950 540 {}
L 4 510 390 950 390 {}
L 4 1100 540 1300 540 {}
L 4 1300 370 1300 540 {}
L 4 1100 370 1300 370 {}
L 4 1100 370 1100 540 {}
L 4 1590 80 1790 80 {}
L 4 1790 -90 1790 80 {}
L 4 1590 -90 1790 -90 {}
L 4 1590 -90 1590 80 {}
L 4 1230 320 1430 320 {}
L 4 1430 150 1430 320 {}
L 4 1230 150 1430 150 {}
L 4 1230 150 1230 320 {}
L 4 980 320 1180 320 {}
L 4 1180 150 1180 320 {}
L 4 980 150 1180 150 {}
L 4 980 150 980 320 {}
L 4 640 320 840 320 {}
L 4 840 150 840 320 {}
L 4 640 150 840 150 {}
L 4 640 150 640 320 {}
L 4 1590 320 1790 320 {}
L 4 1790 150 1790 320 {}
L 4 1590 150 1790 150 {}
L 4 1590 150 1590 320 {}
L 4 1710 790 1910 790 {}
L 4 1910 620 1910 790 {}
L 4 1710 620 1910 620 {}
L 4 1710 620 1710 790 {}
L 4 1460 790 1660 790 {}
L 4 1660 620 1660 790 {}
L 4 1460 620 1660 620 {}
L 4 1460 620 1460 790 {}
L 4 510 640 510 790 {}
L 4 510 790 950 790 {}
L 4 950 640 950 790 {}
L 4 510 640 950 640 {}
L 4 1100 790 1300 790 {}
L 4 1300 620 1300 790 {}
L 4 1100 620 1300 620 {}
L 4 1100 620 1100 790 {}
T {M34} 1310 -70 0 0 0.4 0.4 {}
T {M31} 1060 -70 0 0 0.4 0.4 {}
T {M30} 720 -70 0 0 0.4 0.4 {}
T {M55} 710 430 0 0 0.4 0.4 {}
T {M56} 1180 430 0 0 0.4 0.4 {}
T {M35} 1670 -70 0 0 0.4 0.4 {}
T {M57} 1540 430 0 0 0.4 0.4 {}
T {M61} 1790 430 0 0 0.4 0.4 {}
T {M34} 1310 170 0 0 0.4 0.4 {}
T {M31} 1060 170 0 0 0.4 0.4 {}
T {M30} 720 170 0 0 0.4 0.4 {}
T {M35} 1670 170 0 0 0.4 0.4 {}
T {M55} 710 680 0 0 0.4 0.4 {}
T {M56} 1180 680 0 0 0.4 0.4 {}
T {M57} 1540 680 0 0 0.4 0.4 {}
T {M61} 1790 680 0 0 0.4 0.4 {}
N 3120 620 3120 790 { lab=Vbn}
N 3020 620 3020 790 { lab=Vbn}
N 3020 790 3120 790 { lab=Vbn}
N 3390 530 3710 530 { lab=Vg}
N 3120 790 3710 790 { lab=Vbn}
N 3320 650 3860 650 { lab=#net1}
N 4010 530 4230 530 { lab=Vg}
N 2750 790 3020 790 { lab=Vbn}
N 180 550 230 550 { lab=#net2}
N 3910 530 4010 530 { lab=Vg}
N 4110 620 4140 620 { lab=GND}
N 4140 590 4140 620 { lab=GND}
N 4110 730 4140 730 { lab=GND}
N 4140 700 4140 730 { lab=GND}
N 4110 390 4140 390 { lab=GND}
N 4140 360 4140 390 { lab=GND}
N 4110 500 4140 500 { lab=GND}
N 4140 470 4140 500 { lab=GND}
N 3580 590 3580 620 { lab=GND}
N 3580 620 3610 620 { lab=GND}
N 3580 700 3580 730 { lab=GND}
N 3580 730 3610 730 { lab=GND}
N 3580 360 3580 390 { lab=GND}
N 3580 390 3610 390 { lab=GND}
N 3580 470 3580 500 { lab=GND}
N 3580 500 3610 500 { lab=GND}
N 3660 470 3680 470 { lab=VDD}
N 3660 590 3680 590 { lab=VDD}
N 3660 360 3680 360 { lab=VDD}
N 3660 700 3680 700 { lab=GND}
N 3760 470 3780 470 { lab=#net3}
N 3760 360 3780 360 { lab=#net4}
N 3760 700 3780 700 { lab=#net5}
N 3860 470 3880 470 { lab=#net1}
N 3860 360 3880 360 { lab=#net1}
N 4060 470 4080 470 { lab=VDD}
N 4060 590 4080 590 { lab=VDD}
N 4060 360 4080 360 { lab=VDD}
N 4060 700 4080 700 { lab=GND}
N 3660 330 3660 360 { lab=VDD}
N 3640 360 3660 360 { lab=VDD}
N 3660 360 3660 470 { lab=VDD}
N 3640 470 3660 470 { lab=VDD}
N 3660 470 3660 590 { lab=VDD}
N 3640 590 3660 590 { lab=VDD}
N 3640 700 3660 700 { lab=GND}
N 3960 470 3980 470 { lab=#net3}
N 3960 360 3980 360 { lab=#net4}
N 3960 700 3980 700 { lab=#net5}
N 4060 330 4060 360 { lab=VDD}
N 4060 360 4060 470 { lab=VDD}
N 4060 470 4060 590 { lab=VDD}
N 4040 360 4060 360 { lab=VDD}
N 4040 470 4060 470 { lab=VDD}
N 4040 590 4060 590 { lab=VDD}
N 4040 700 4060 700 { lab=GND}
N 3760 590 3780 590 { lab=#net6}
N 3860 590 3880 590 { lab=#net1}
N 3960 590 3980 590 { lab=#net6}
N 3710 530 3710 560 { lab=Vg}
N 3710 390 3710 530 { lab=Vg}
N 3810 530 3810 560 { lab=Vg}
N 3710 530 3810 530 { lab=Vg}
N 3810 390 3810 530 { lab=Vg}
N 3910 530 3910 560 { lab=Vg}
N 3910 390 3910 530 { lab=Vg}
N 3810 530 3910 530 { lab=Vg}
N 4010 530 4010 560 { lab=Vg}
N 3860 360 3860 470 { lab=#net1}
N 3840 360 3860 360 { lab=#net1}
N 3840 470 3860 470 { lab=#net1}
N 3860 470 3860 590 { lab=#net1}
N 3840 590 3860 590 { lab=#net1}
N 3760 670 3760 700 { lab=#net5}
N 3740 700 3760 700 { lab=#net5}
N 3760 670 3960 670 { lab=#net5}
N 3960 670 3960 700 { lab=#net5}
N 3940 700 3960 700 { lab=#net5}
N 3760 590 3760 620 { lab=#net6}
N 3740 590 3760 590 { lab=#net6}
N 3760 620 3960 620 { lab=#net6}
N 3960 590 3960 620 { lab=#net6}
N 3940 590 3960 590 { lab=#net6}
N 3960 440 3960 470 { lab=#net3}
N 3940 470 3960 470 { lab=#net3}
N 3760 440 3960 440 { lab=#net3}
N 3760 440 3760 470 { lab=#net3}
N 3740 470 3760 470 { lab=#net3}
N 3760 330 3760 360 { lab=#net4}
N 3740 360 3760 360 { lab=#net4}
N 3760 330 3960 330 { lab=#net4}
N 3960 330 3960 360 { lab=#net4}
N 3940 360 3960 360 { lab=#net4}
N 4010 730 4010 790 { lab=Vbn}
N 3910 730 3910 790 { lab=Vbn}
N 3810 730 3810 790 { lab=Vbn}
N 3710 730 3710 790 { lab=Vbn}
N 3910 790 4010 790 { lab=Vbn}
N 3810 790 3910 790 { lab=Vbn}
N 3710 790 3810 790 { lab=Vbn}
N 3860 650 3860 700 { lab=#net1}
N 4010 390 4010 530 { lab=Vg}
N 3860 590 3860 650 { lab=#net1}
N 3840 700 3860 700 { lab=#net1}
N 3860 700 3880 700 { lab=#net1}
N 3050 470 3090 470 { lab=#net7}
N 3050 590 3090 590 { lab=#net8}
N 3170 590 3190 590 { lab=GND}
N 3170 470 3190 470 { lab=VDD}
N 3250 470 3290 470 { lab=#net9}
N 3250 590 3290 590 { lab=#net10}
N 3350 590 3390 590 { lab=Vg}
N 3350 470 3390 470 { lab=Vg}
N 3250 700 3290 700 { lab=#net10}
N 2950 700 2990 700 { lab=#net11}
N 3050 700 3090 700 { lab=#net8}
N 3170 700 3190 700 { lab=GND}
N 2950 470 2990 470 { lab=#net11}
N 2950 590 2990 590 { lab=#net11}
N 3350 700 3390 700 { lab=Vg}
N 3170 590 3170 700 { lab=GND}
N 3170 700 3170 750 { lab=GND}
N 3120 410 3120 440 { lab=#net11}
N 3020 410 3020 440 { lab=#net11}
N 3220 410 3220 440 { lab=#net11}
N 3320 410 3320 440 { lab=#net11}
N 2950 590 2950 700 { lab=#net11}
N 3390 590 3390 700 { lab=Vg}
N 3050 360 3090 360 { lab=#net7}
N 3170 360 3190 360 { lab=VDD}
N 3250 360 3290 360 { lab=#net9}
N 3350 360 3390 360 { lab=Vg}
N 2950 360 2990 360 { lab=#net11}
N 2950 410 2950 470 { lab=#net11}
N 3390 360 3390 470 { lab=Vg}
N 3170 360 3170 470 { lab=VDD}
N 3170 330 3170 360 { lab=VDD}
N 2950 470 2950 590 { lab=#net11}
N 3390 530 3390 590 { lab=Vg}
N 3020 410 3120 410 { lab=#net11}
N 2890 440 2920 440 { lab=VDD}
N 2890 440 2890 470 { lab=VDD}
N 2890 330 2920 330 { lab=VDD}
N 2890 330 2890 360 { lab=VDD}
N 2890 590 2890 620 { lab=GND}
N 2890 620 2920 620 { lab=GND}
N 2890 700 2890 730 { lab=GND}
N 2890 730 2920 730 { lab=GND}
N 3420 620 3450 620 { lab=GND}
N 3450 590 3450 620 { lab=GND}
N 3420 730 3450 730 { lab=GND}
N 3450 700 3450 730 { lab=GND}
N 3420 440 3450 440 { lab=VDD}
N 3450 440 3450 470 { lab=VDD}
N 3420 330 3450 330 { lab=VDD}
N 3450 330 3450 360 { lab=VDD}
N 3120 410 3220 410 { lab=#net11}
N 3220 410 3320 410 { lab=#net11}
N 2950 410 3020 410 { lab=#net11}
N 3150 590 3170 590 { lab=GND}
N 3150 700 3170 700 { lab=GND}
N 3150 360 3170 360 { lab=VDD}
N 3150 470 3170 470 { lab=VDD}
N 3020 390 3020 410 { lab=#net11}
N 3120 390 3120 410 { lab=#net11}
N 3220 390 3220 410 { lab=#net11}
N 3320 390 3320 410 { lab=#net11}
N 2950 360 2950 410 { lab=#net11}
N 3390 470 3390 530 { lab=Vg}
N 3220 650 3220 670 { lab=#net1}
N 3320 650 3320 670 { lab=#net1}
N 3220 650 3320 650 { lab=#net1}
N 3220 620 3220 650 { lab=#net1}
N 3320 620 3320 650 { lab=#net1}
N 3070 360 3070 470 { lab=#net7}
N 3270 360 3270 470 { lab=#net9}
N 3070 590 3070 700 { lab=#net8}
N 3270 590 3270 700 { lab=#net10}
N -230 1120 -190 1120 { lab=VDD}
N -130 1120 -90 1120 { lab=#net12}
N -30 1120 10 1120 { lab=#net13}
N 70 1120 110 1120 { lab=VDD}
N 170 1120 210 1120 { lab=VDD}
N 270 1120 310 1120 { lab=#net14}
N 370 1120 410 1120 { lab=#net15}
N 470 1120 510 1120 { lab=VDD}
N 570 1120 610 1120 { lab=#net16}
N 670 1120 710 1120 { lab=VDD}
N 770 1120 810 1120 { lab=#net17}
N 870 1120 910 1120 { lab=VDD}
N 970 1120 1010 1120 { lab=#net18}
N 1070 1120 1110 1120 { lab=#net19}
N -230 1350 -190 1350 { lab=#net12}
N -130 1350 -90 1350 { lab=#net13}
N -30 1350 10 1350 { lab=#net14}
N 70 1350 110 1350 { lab=#net13}
N 170 1350 210 1350 { lab=#net15}
N 270 1350 310 1350 { lab=#net14}
N 370 1350 410 1350 { lab=#net15}
N 470 1350 510 1350 { lab=#net16}
N 570 1350 610 1350 { lab=#net15}
N 670 1350 710 1350 { lab=#net17}
N 770 1350 810 1350 { lab=#net16}
N 870 1350 910 1350 { lab=#net17}
N 970 1350 1010 1350 { lab=#net18}
N -30 1560 10 1560 { lab=#net12}
N 70 1560 110 1560 { lab=#net13}
N 170 1560 210 1560 { lab=GND}
N 270 1560 310 1560 { lab=#net14}
N 370 1560 410 1560 { lab=#net15}
N 470 1560 510 1560 { lab=GND}
N 570 1560 610 1560 { lab=#net16}
N 670 1560 710 1560 { lab=#net17}
N 770 1560 810 1560 { lab=GND}
N -430 1660 1430 1660 { lab=GND}
N -110 1560 -110 1660 { lab=GND}
N -60 1590 -60 1700 { lab=b0}
N 140 1590 140 1690 { lab=b1}
N 240 1590 240 1690 { lab=b2}
N 440 1590 440 1690 { lab=b3}
N 540 1590 540 1690 { lab=b4}
N 740 1590 740 1690 { lab=b5}
N 840 1590 840 1690 { lab=b6}
N -470 1060 1390 1060 { lab=Vg}
N 40 1590 40 1660 { lab=GND}
N 340 1590 340 1660 { lab=GND}
N 640 1590 640 1660 { lab=GND}
N 790 1560 790 1660 { lab=GND}
N 190 1560 190 1660 { lab=GND}
N 490 1560 490 1660 { lab=GND}
N -260 1060 -260 1090 { lab=Vg}
N -160 1060 -160 1090 { lab=Vg}
N 40 1060 40 1090 { lab=Vg}
N 240 1060 240 1090 { lab=Vg}
N 440 1060 440 1090 { lab=Vg}
N 640 1060 640 1090 { lab=Vg}
N 840 1060 840 1090 { lab=Vg}
N 1040 1060 1040 1090 { lab=Vg}
N 1140 1060 1140 1090 { lab=Vg}
N -310 1120 -310 1180 { lab=#net12}
N -310 1180 -110 1180 { lab=#net12}
N -110 1120 -110 1180 { lab=#net12}
N 990 1120 990 1180 { lab=#net18}
N 990 1180 1190 1180 { lab=#net18}
N 1190 1120 1190 1180 { lab=#net18}
N -60 1090 -60 1200 { lab=GND}
N 140 1090 140 1200 { lab=GND}
N 340 1090 340 1200 { lab=GND}
N 540 1090 540 1200 { lab=GND}
N 740 1090 740 1200 { lab=GND}
N 940 1090 940 1200 { lab=GND}
N -490 1200 940 1200 { lab=GND}
N -490 1660 -430 1660 { lab=GND}
N -310 1350 -310 1420 { lab=#net13}
N -310 1420 90 1420 { lab=#net13}
N 90 1350 90 1420 { lab=#net13}
N 690 1350 690 1420 { lab=#net17}
N 690 1420 1090 1420 { lab=#net17}
N 1090 1350 1090 1420 { lab=#net17}
N 190 1350 190 1420 { lab=#net15}
N 190 1420 590 1420 { lab=#net15}
N 590 1350 590 1420 { lab=#net15}
N 140 1200 140 1320 { lab=GND}
N 640 1200 640 1320 { lab=GND}
N -260 1310 -260 1320 { lab=Vg}
N -260 1310 1040 1310 { lab=Vg}
N 1040 1310 1040 1320 { lab=Vg}
N 940 1310 940 1320 { lab=Vg}
N 840 1310 840 1320 { lab=Vg}
N 740 1310 740 1320 { lab=Vg}
N 540 1310 540 1320 { lab=Vg}
N 440 1310 440 1320 { lab=Vg}
N 340 1310 340 1320 { lab=Vg}
N 240 1310 240 1320 { lab=Vg}
N 40 1310 40 1320 { lab=Vg}
N -60 1310 -60 1320 { lab=Vg}
N -160 1310 -160 1320 { lab=Vg}
N -210 960 -210 1120 { lab=VDD}
N -470 1310 -260 1310 { lab=Vg}
N -210 1180 -210 1350 { lab=#net12}
N -210 1350 -210 1490 { lab=#net12}
N -210 1490 -10 1490 { lab=#net12}
N -10 1490 -10 1560 { lab=#net12}
N -110 1350 -110 1420 { lab=#net13}
N -110 1230 -110 1350 { lab=#net13}
N -110 1230 -10 1230 { lab=#net13}
N -10 1120 -10 1230 { lab=#net13}
N 90 960 90 1120 { lab=VDD}
N -110 1420 -110 1470 { lab=#net13}
N -110 1470 90 1470 { lab=#net13}
N 90 1470 90 1560 { lab=#net13}
N 190 960 190 1120 { lab=VDD}
N 1090 1040 1090 1120 { lab=#net19}
N 1090 1040 1390 1040 { lab=#net19}
N 290 1120 290 1250 { lab=#net14}
N -10 1250 290 1250 { lab=#net14}
N -10 1250 -10 1350 { lab=#net14}
N 290 1250 290 1350 { lab=#net14}
N 490 960 490 1120 { lab=VDD}
N 290 1350 290 1560 { lab=#net14}
N 990 1350 990 1480 { lab=#net18}
N 990 1180 990 1350 { lab=#net18}
N 790 1120 790 1230 { lab=#net17}
N 790 1230 890 1230 { lab=#net17}
N 890 1230 890 1350 { lab=#net17}
N 890 1350 890 1420 { lab=#net17}
N 690 1420 690 1560 { lab=#net17}
N 590 1270 790 1270 { lab=#net16}
N 790 1270 790 1350 { lab=#net16}
N 790 1350 790 1460 { lab=#net16}
N 590 1460 790 1460 { lab=#net16}
N 590 1460 590 1560 { lab=#net16}
N 390 1120 390 1350 { lab=#net15}
N 390 1350 390 1420 { lab=#net15}
N 390 1420 390 1560 { lab=#net15}
N 490 1350 490 1460 { lab=#net16}
N 490 1460 590 1460 { lab=#net16}
N -530 1060 -470 1060 { lab=Vg}
N -530 1060 -530 1310 { lab=Vg}
N -530 1310 -470 1310 { lab=Vg}
N -510 1200 -490 1200 { lab=GND}
N -510 1200 -510 1660 { lab=GND}
N -510 1660 -490 1660 { lab=GND}
N 590 1120 590 1270 { lab=#net16}
N -460 1090 -360 1090 { lab=GND}
N -430 1120 -390 1120 { lab=GND}
N -490 1090 -490 1120 { lab=GND}
N -490 1090 -460 1090 { lab=GND}
N -410 1090 -410 1120 { lab=GND}
N -330 1120 -290 1120 { lab=#net12}
N -410 1120 -410 1200 { lab=GND}
N 1170 1120 1210 1120 { lab=#net18}
N 1240 1090 1340 1090 { lab=GND}
N 1340 1090 1370 1090 { lab=GND}
N 1370 1090 1370 1120 { lab=GND}
N 1270 1120 1310 1120 { lab=GND}
N 1290 1090 1290 1120 { lab=GND}
N 940 1200 1290 1200 { lab=GND}
N 1290 1120 1290 1200 { lab=GND}
N -330 1350 -290 1350 { lab=#net13}
N -460 1320 -360 1320 { lab=GND}
N -490 1320 -460 1320 { lab=GND}
N -490 1320 -490 1350 { lab=GND}
N -430 1350 -390 1350 { lab=GND}
N -410 1320 -410 1350 { lab=GND}
N -510 1350 -490 1350 { lab=GND}
N -430 1560 -390 1560 { lab=GND}
N -330 1560 -290 1560 { lab=GND}
N -230 1560 -190 1560 { lab=GND}
N -130 1560 -90 1560 { lab=GND}
N -490 1590 -160 1590 { lab=GND}
N -490 1560 -490 1590 { lab=GND}
N -410 1560 -410 1590 { lab=GND}
N -310 1560 -310 1590 { lab=GND}
N -210 1560 -210 1590 { lab=GND}
N -310 1590 -310 1660 { lab=GND}
N 890 1480 890 1560 { lab=#net18}
N 890 1480 990 1480 { lab=#net18}
N 870 1560 910 1560 { lab=#net18}
N 940 1590 1370 1590 { lab=GND}
N 1370 1560 1370 1590 { lab=GND}
N 1270 1560 1310 1560 { lab=GND}
N 1170 1560 1210 1560 { lab=GND}
N 1070 1560 1110 1560 { lab=GND}
N 970 1560 1010 1560 { lab=GND}
N 990 1560 990 1590 { lab=GND}
N 1090 1560 1090 1590 { lab=GND}
N 1190 1560 1190 1590 { lab=GND}
N 1290 1560 1290 1590 { lab=GND}
N 1140 1590 1140 1660 { lab=GND}
N 1070 1350 1110 1350 { lab=#net17}
N 1170 1350 1210 1350 { lab=GND}
N 1270 1350 1310 1350 { lab=GND}
N 1140 1320 1370 1320 { lab=GND}
N 1370 1320 1370 1350 { lab=GND}
N 1290 1320 1290 1350 { lab=GND}
N 1190 1320 1190 1350 { lab=GND}
N 1290 1200 1290 1320 { lab=GND}
N -530 960 1430 960 { lab=VDD}
N -530 940 -530 960 { lab=VDD}
N -510 1660 -510 1700 { lab=GND}
N 890 960 890 1120 { lab=VDD}
N 690 960 690 1120 { lab=VDD}
N 840 1690 960 1690 { lab=b6}
N 960 1690 960 1780 { lab=b6}
N 770 1690 770 1780 { lab=b5}
N 580 1690 580 1780 { lab=b4}
N 390 1690 390 1780 { lab=b3}
N 200 1690 200 1780 { lab=b2}
N -10 1690 -10 1780 { lab=b1}
N -220 1700 -220 1780 { lab=b0}
N -220 1700 -60 1700 { lab=b0}
N -570 1060 -530 1060 { lab=Vg}
N 1400 1040 1420 1040 { lab=#net19}
N 1390 1040 1400 1040 { lab=#net19}
N 30 1820 40 1820 { lab=Q1}
N 40 1820 40 1910 { lab=Q1}
N -180 1820 -170 1820 { lab=Q0}
N -170 1820 -170 1910 { lab=Q0}
N -130 1900 -30 1900 { lab=Vbn}
N -30 1900 70 1900 { lab=Vbn}
N -240 1860 -240 1900 { lab=Vbn}
N -30 1860 -30 1900 { lab=Vbn}
N 240 1820 250 1820 { lab=Q2}
N 250 1820 250 1910 { lab=Q2}
N 180 1900 370 1900 { lab=Vbn}
N 180 1860 180 1900 { lab=Vbn}
N 430 1820 440 1820 { lab=Q3}
N 440 1820 440 1910 { lab=Q3}
N 370 1900 560 1900 { lab=Vbn}
N 370 1860 370 1900 { lab=Vbn}
N 620 1820 630 1820 { lab=Q4}
N 630 1820 630 1910 { lab=Q4}
N 560 1900 750 1900 { lab=Vbn}
N 560 1860 560 1900 { lab=Vbn}
N 810 1820 820 1820 { lab=Q5}
N 820 1820 820 1910 { lab=Q5}
N 750 1900 940 1900 { lab=Vbn}
N 750 1860 750 1900 { lab=Vbn}
N 70 1900 180 1900 { lab=Vbn}
N 940 1860 940 1900 { lab=Vbn}
N 1000 1820 1010 1820 { lab=Q6}
N 1010 1820 1010 1910 { lab=Q6}
N -240 1900 -130 1900 { lab=Vbn}
N 740 1690 770 1690 { lab=b5}
N 540 1690 580 1690 { lab=b4}
N 390 1690 440 1690 { lab=b3}
N 200 1690 240 1690 { lab=b2}
N -10 1690 140 1690 { lab=b1}
N 2950 1170 2950 1190 { lab=#net20}
N 2950 1190 3150 1190 { lab=#net20}
N 3150 1170 3150 1190 { lab=#net20}
N 3050 1170 3050 1190 { lab=#net20}
N 2880 1140 2920 1140 { lab=#net21}
N 2980 1140 3020 1140 { lab=VDD}
N 3080 1140 3120 1140 { lab=#net22}
N 2800 1140 2800 1190 { lab=#net23}
N 2800 1190 2800 1260 { lab=#net23}
N 2900 1140 2900 1300 { lab=#net21}
N 3150 1190 3200 1190 { lab=#net20}
N 3200 1140 3220 1140 { lab=#net20}
N 3200 1190 3450 1190 { lab=#net20}
N 3450 1170 3450 1190 { lab=#net20}
N 3350 1170 3350 1190 { lab=#net20}
N 3250 1170 3250 1190 { lab=#net20}
N 3280 1140 3320 1140 { lab=#net22}
N 3380 1140 3420 1140 { lab=VDD}
N 3480 1140 3520 1140 { lab=#net21}
N 3600 1140 3600 1190 { lab=#net23}
N 3600 1190 3600 1260 { lab=#net23}
N 3500 1140 3500 1300 { lab=#net21}
N 3180 1140 3200 1140 { lab=#net20}
N 2750 950 2750 1170 { lab=VDD}
N 3650 950 3650 1170 { lab=VDD}
N 2580 1140 2620 1140 { lab=Vout_dac}
N 2600 1140 2600 1220 { lab=Vout_dac}
N 2680 1140 2720 1140 { lab=#net22}
N 2780 1140 2820 1140 { lab=#net23}
N 2650 1170 2650 1190 { lab=#net23}
N 2650 1190 2820 1190 { lab=#net23}
N 2820 1190 2850 1190 { lab=#net23}
N 2850 1170 2850 1190 { lab=#net23}
N 3580 1140 3620 1140 { lab=#net23}
N 3680 1140 3720 1140 { lab=#net22}
N 3550 1170 3550 1190 { lab=#net23}
N 3550 1190 3600 1190 { lab=#net23}
N 3600 1190 3750 1190 { lab=#net23}
N 3750 1170 3750 1190 { lab=#net23}
N 3780 1140 3820 1140 { lab=Vout_dac}
N 3800 1140 3800 1220 { lab=Vout_dac}
N 2700 1040 2700 1140 { lab=#net22}
N 2700 1040 3700 1040 { lab=#net22}
N 3700 1040 3700 1140 { lab=#net22}
N 3300 1040 3300 1140 { lab=#net22}
N 3100 1040 3100 1140 { lab=#net22}
N 3000 950 3000 1140 { lab=VDD}
N 3400 950 3400 1140 { lab=VDD}
N 2800 1260 2800 1330 { lab=#net23}
N 3600 1260 3600 1330 { lab=#net23}
N 2800 1330 3600 1330 { lab=#net23}
N 2480 1140 2520 1140 { lab=VDD}
N 2550 1170 2550 1190 { lab=VDD}
N 2500 1140 2500 1190 { lab=VDD}
N 2500 950 2500 1140 { lab=VDD}
N 3850 1170 3850 1190 { lab=VDD}
N 3850 1190 3900 1190 { lab=VDD}
N 3900 1140 3900 1190 { lab=VDD}
N 3880 1140 3920 1140 { lab=VDD}
N 3900 950 3900 1140 { lab=VDD}
N 2070 950 4250 950 { lab=VDD}
N 2200 1140 2220 1140 { lab=VDD}
N 2200 1140 2200 1190 { lab=VDD}
N 2200 1190 2550 1190 { lab=VDD}
N 2280 1140 2320 1140 { lab=VDD}
N 2380 1140 2420 1140 { lab=VDD}
N 2400 1140 2400 1190 { lab=VDD}
N 2300 1140 2300 1190 { lab=VDD}
N 2350 1170 2350 1190 { lab=VDD}
N 2250 1170 2250 1190 { lab=VDD}
N 2450 1170 2450 1190 { lab=VDD}
N 3950 1170 3950 1190 { lab=VDD}
N 3950 1190 4100 1190 { lab=VDD}
N 4100 1140 4100 1190 { lab=VDD}
N 4080 1140 4100 1140 { lab=VDD}
N 4050 1170 4050 1190 { lab=VDD}
N 3980 1140 4020 1140 { lab=VDD}
N 4000 1140 4000 1190 { lab=VDD}
N 3900 1190 3950 1190 { lab=VDD}
N 3200 1140 3200 1390 { lab=#net20}
N 2290 1750 2330 1750 { lab=VDD}
N 2390 1750 2430 1750 { lab=#net24}
N 2490 1750 2530 1750 { lab=#net25}
N 2590 1750 2630 1750 { lab=VDD}
N 2690 1750 2730 1750 { lab=VDD}
N 2790 1750 2830 1750 { lab=#net26}
N 2890 1750 2930 1750 { lab=#net27}
N 2990 1750 3030 1750 { lab=VDD}
N 3090 1750 3130 1750 { lab=#net28}
N 3190 1750 3230 1750 { lab=VDD}
N 3290 1750 3330 1750 { lab=#net29}
N 3390 1750 3430 1750 { lab=#net20}
N 3490 1750 3530 1750 { lab=#net30}
N 3590 1750 3630 1750 { lab=#net23}
N 2290 1980 2330 1980 { lab=#net24}
N 2390 1980 2430 1980 { lab=#net25}
N 2490 1980 2530 1980 { lab=#net26}
N 2590 1980 2630 1980 { lab=#net25}
N 2690 1980 2730 1980 { lab=#net27}
N 2790 1980 2830 1980 { lab=#net26}
N 2890 1980 2930 1980 { lab=#net27}
N 2990 1980 3030 1980 { lab=#net28}
N 3090 1980 3130 1980 { lab=#net27}
N 3190 1980 3230 1980 { lab=#net29}
N 3290 1980 3330 1980 { lab=#net28}
N 3390 1980 3430 1980 { lab=#net29}
N 3490 1980 3530 1980 { lab=#net30}
N 2490 2190 2530 2190 { lab=#net24}
N 2590 2190 2630 2190 { lab=#net25}
N 2690 2190 2730 2190 { lab=GND}
N 2790 2190 2830 2190 { lab=#net26}
N 2890 2190 2930 2190 { lab=#net27}
N 2990 2190 3030 2190 { lab=GND}
N 3090 2190 3130 2190 { lab=#net28}
N 3190 2190 3230 2190 { lab=#net29}
N 3290 2190 3330 2190 { lab=GND}
N 2090 2290 3950 2290 { lab=GND}
N 2410 2190 2410 2290 { lab=GND}
N 2050 1690 3910 1690 { lab=Vg}
N 2560 2220 2560 2290 { lab=GND}
N 2860 2220 2860 2290 { lab=GND}
N 3160 2220 3160 2290 { lab=GND}
N 3310 2190 3310 2290 { lab=GND}
N 2710 2190 2710 2290 { lab=GND}
N 3010 2190 3010 2290 { lab=GND}
N 2260 1690 2260 1720 { lab=Vg}
N 2360 1690 2360 1720 { lab=Vg}
N 2560 1690 2560 1720 { lab=Vg}
N 2760 1690 2760 1720 { lab=Vg}
N 2960 1690 2960 1720 { lab=Vg}
N 3160 1690 3160 1720 { lab=Vg}
N 3360 1690 3360 1720 { lab=Vg}
N 3560 1690 3560 1720 { lab=Vg}
N 3660 1690 3660 1720 { lab=Vg}
N 2210 1750 2210 1810 { lab=#net24}
N 2210 1810 2410 1810 { lab=#net24}
N 2410 1750 2410 1810 { lab=#net24}
N 3510 1750 3510 1810 { lab=#net30}
N 3510 1810 3710 1810 { lab=#net30}
N 3710 1750 3710 1810 { lab=#net30}
N 2460 1720 2460 1830 { lab=GND}
N 2660 1720 2660 1830 { lab=GND}
N 2860 1720 2860 1830 { lab=GND}
N 3060 1720 3060 1830 { lab=GND}
N 3260 1720 3260 1830 { lab=GND}
N 3460 1720 3460 1830 { lab=GND}
N 2030 1830 3460 1830 { lab=GND}
N 2030 2290 2090 2290 { lab=GND}
N 2210 1980 2210 2050 { lab=#net25}
N 2210 2050 2610 2050 { lab=#net25}
N 2610 1980 2610 2050 { lab=#net25}
N 3210 1980 3210 2050 { lab=#net29}
N 3210 2050 3610 2050 { lab=#net29}
N 3610 1980 3610 2050 { lab=#net29}
N 2710 1980 2710 2050 { lab=#net27}
N 2710 2050 3110 2050 { lab=#net27}
N 3110 1980 3110 2050 { lab=#net27}
N 2660 1830 2660 1950 { lab=GND}
N 3160 1830 3160 1950 { lab=GND}
N 2260 1940 2260 1950 { lab=Vg}
N 2260 1940 3560 1940 { lab=Vg}
N 3560 1940 3560 1950 { lab=Vg}
N 3460 1940 3460 1950 { lab=Vg}
N 3360 1940 3360 1950 { lab=Vg}
N 3260 1940 3260 1950 { lab=Vg}
N 3060 1940 3060 1950 { lab=Vg}
N 2960 1940 2960 1950 { lab=Vg}
N 2860 1940 2860 1950 { lab=Vg}
N 2760 1940 2760 1950 { lab=Vg}
N 2560 1940 2560 1950 { lab=Vg}
N 2460 1940 2460 1950 { lab=Vg}
N 2360 1940 2360 1950 { lab=Vg}
N 2310 1590 2310 1750 { lab=VDD}
N 2050 1940 2260 1940 { lab=Vg}
N 2310 1810 2310 1980 { lab=#net24}
N 2310 1980 2310 2120 { lab=#net24}
N 2310 2120 2510 2120 { lab=#net24}
N 2510 2120 2510 2190 { lab=#net24}
N 2410 1980 2410 2050 { lab=#net25}
N 2410 1860 2410 1980 { lab=#net25}
N 2410 1860 2510 1860 { lab=#net25}
N 2510 1750 2510 1860 { lab=#net25}
N 2610 1590 2610 1750 { lab=VDD}
N 2410 2050 2410 2100 { lab=#net25}
N 2410 2100 2610 2100 { lab=#net25}
N 2610 2100 2610 2190 { lab=#net25}
N 2710 1590 2710 1750 { lab=VDD}
N 3610 1670 3610 1750 { lab=#net23}
N 2810 1750 2810 1880 { lab=#net26}
N 2510 1880 2810 1880 { lab=#net26}
N 2510 1880 2510 1980 { lab=#net26}
N 2810 1880 2810 1980 { lab=#net26}
N 3010 1590 3010 1750 { lab=VDD}
N 2810 1980 2810 2190 { lab=#net26}
N 3510 1980 3510 2110 { lab=#net30}
N 3510 1810 3510 1980 { lab=#net30}
N 3310 1750 3310 1860 { lab=#net29}
N 3310 1860 3410 1860 { lab=#net29}
N 3410 1860 3410 1980 { lab=#net29}
N 3410 1980 3410 2050 { lab=#net29}
N 3210 2050 3210 2190 { lab=#net29}
N 3110 1900 3310 1900 { lab=#net28}
N 3310 1900 3310 1980 { lab=#net28}
N 3310 1980 3310 2090 { lab=#net28}
N 3110 2090 3310 2090 { lab=#net28}
N 3110 2090 3110 2190 { lab=#net28}
N 2910 1750 2910 1980 { lab=#net27}
N 2910 1980 2910 2050 { lab=#net27}
N 2910 2050 2910 2190 { lab=#net27}
N 3010 1980 3010 2090 { lab=#net28}
N 3010 2090 3110 2090 { lab=#net28}
N 1990 1690 2050 1690 { lab=Vg}
N 1990 1690 1990 1940 { lab=Vg}
N 1990 1940 2050 1940 { lab=Vg}
N 2010 1830 2030 1830 { lab=GND}
N 2010 1830 2010 2290 { lab=GND}
N 2010 2290 2030 2290 { lab=GND}
N 3110 1750 3110 1900 { lab=#net28}
N 2060 1720 2160 1720 { lab=GND}
N 2090 1750 2130 1750 { lab=GND}
N 2030 1720 2030 1750 { lab=GND}
N 2030 1720 2060 1720 { lab=GND}
N 2110 1720 2110 1750 { lab=GND}
N 2190 1750 2230 1750 { lab=#net24}
N 2110 1750 2110 1830 { lab=GND}
N 3690 1750 3730 1750 { lab=#net30}
N 3760 1720 3860 1720 { lab=GND}
N 3860 1720 3890 1720 { lab=GND}
N 3890 1720 3890 1750 { lab=GND}
N 3790 1750 3830 1750 { lab=GND}
N 3810 1720 3810 1750 { lab=GND}
N 3460 1830 3810 1830 { lab=GND}
N 3810 1750 3810 1830 { lab=GND}
N 2190 1980 2230 1980 { lab=#net25}
N 2060 1950 2160 1950 { lab=GND}
N 2030 1950 2060 1950 { lab=GND}
N 2030 1950 2030 1980 { lab=GND}
N 2090 1980 2130 1980 { lab=GND}
N 2110 1950 2110 1980 { lab=GND}
N 2010 1980 2030 1980 { lab=GND}
N 2090 2190 2130 2190 { lab=GND}
N 2190 2190 2230 2190 { lab=GND}
N 2290 2190 2330 2190 { lab=GND}
N 2390 2190 2430 2190 { lab=GND}
N 2030 2220 2360 2220 { lab=GND}
N 2030 2190 2030 2220 { lab=GND}
N 2110 2190 2110 2220 { lab=GND}
N 2210 2190 2210 2220 { lab=GND}
N 2310 2190 2310 2220 { lab=GND}
N 2210 2220 2210 2290 { lab=GND}
N 3410 2110 3410 2190 { lab=#net30}
N 3410 2110 3510 2110 { lab=#net30}
N 3390 2190 3430 2190 { lab=#net30}
N 3460 2220 3890 2220 { lab=GND}
N 3890 2190 3890 2220 { lab=GND}
N 3790 2190 3830 2190 { lab=GND}
N 3690 2190 3730 2190 { lab=GND}
N 3590 2190 3630 2190 { lab=GND}
N 3490 2190 3530 2190 { lab=GND}
N 3510 2190 3510 2220 { lab=GND}
N 3610 2190 3610 2220 { lab=GND}
N 3710 2190 3710 2220 { lab=GND}
N 3810 2190 3810 2220 { lab=GND}
N 3660 2220 3660 2290 { lab=GND}
N 3590 1980 3630 1980 { lab=#net29}
N 3690 1980 3730 1980 { lab=GND}
N 3790 1980 3830 1980 { lab=GND}
N 3660 1950 3890 1950 { lab=GND}
N 3890 1950 3890 1980 { lab=GND}
N 3810 1950 3810 1980 { lab=GND}
N 3710 1950 3710 1980 { lab=GND}
N 3810 1830 3810 1950 { lab=GND}
N 1990 1590 3950 1590 { lab=VDD}
N 1990 1570 1990 1590 { lab=VDD}
N 2010 2290 2010 2330 { lab=GND}
N 3210 1590 3210 1750 { lab=VDD}
N 3360 2220 3360 2290 { lab=GND}
N 3260 2220 3260 2290 { lab=GND}
N 3060 2220 3060 2290 { lab=GND}
N 2960 2220 2960 2290 { lab=GND}
N 2760 2220 2760 2290 { lab=GND}
N 2660 2220 2660 2290 { lab=GND}
N 3600 1330 3600 1560 { lab=#net23}
N 3600 1560 3610 1560 { lab=#net23}
N 3200 1390 3410 1390 { lab=#net20}
N 1700 1040 2020 1040 { lab=#net21}
N 2020 1040 2020 1300 { lab=#net21}
N 1900 1220 3800 1220 { lab=Vout_dac}
N 1420 1040 1690 1040 { lab=#net19}
N 3610 1560 3610 1670 { lab=#net23}
N 3410 1400 3410 1750 { lab=#net20}
N 3410 1390 3410 1400 { lab=#net20}
N 2020 1300 3500 1300 { lab=#net21}
N 4010 790 4230 790 { lab=Vbn}
N 910 420 910 440 { lab=#net31}
N 790 420 790 440 { lab=#net31}
N 670 420 670 440 { lab=#net31}
N 550 420 550 440 { lab=#net31}
N 580 470 640 470 { lab=#net31}
N 700 470 760 470 { lab=#net32}
N 820 470 880 470 { lab=#net31}
N 700 10 760 10 { lab=#net33}
N 1060 10 1120 10 { lab=#net34}
N 1300 10 1360 10 { lab=#net35}
N 1660 10 1720 10 { lab=#net36}
N 1030 40 1030 60 { lab=Vdp}
N 1390 40 1390 60 { lab=Vdp}
N 1150 40 1150 60 { lab=Vdp}
N 1270 40 1270 60 { lab=Vdp}
N 670 40 670 90 { lab=Vbp}
N 1750 40 1750 90 { lab=Vbp}
N 1630 40 1630 90 { lab=Vbp}
N 790 40 790 90 { lab=Vbp}
N 610 -110 610 10 { lab=VDD}
N 1810 -110 1810 10 { lab=VDD}
N 1180 10 1240 10 { lab=VDD}
N 1210 -110 1210 10 { lab=VDD}
N 1150 420 1150 440 { lab=#net31}
N 1270 420 1270 440 { lab=#net31}
N 1180 470 1240 470 { lab=#net37}
N 1540 470 1600 470 { lab=#net38}
N 1780 470 1840 470 { lab=#net39}
N 970 470 970 550 { lab=#net32}
N 1510 420 1510 440 { lab=Vbn}
N 1870 420 1870 440 { lab=Vbn}
N 1750 420 1750 440 { lab=Vbn}
N 1630 420 1630 440 { lab=Vbn}
N 1660 470 1720 470 { lab=GND}
N 1690 470 1690 590 { lab=GND}
N 1090 470 1090 590 { lab=GND}
N 1930 420 1930 470 { lab=Vbn}
N 1450 90 1450 230 { lab=Vbp}
N 820 10 880 10 { lab=#net31}
N 940 10 1000 10 { lab=Vdp}
N 850 10 850 180 { lab=#net31}
N 1540 10 1600 10 { lab=Vbn}
N 1570 10 1570 180 { lab=Vbn}
N 1420 10 1480 10 { lab=Vbp}
N 1450 10 1450 90 { lab=Vbp}
N 1060 470 1120 470 { lab=GND}
N 940 470 1000 470 { lab=#net32}
N 1300 470 1360 470 { lab=Vdp}
N 1330 60 1330 230 { lab=Vdp}
N 1420 470 1480 470 { lab=Vbp}
N 1900 470 1960 470 { lab=Vbn}
N 1780 10 1840 10 { lab=VDD}
N 1930 -110 1930 10 { lab=VDD}
N 970 10 970 60 { lab=Vdp}
N 970 60 1390 60 { lab=Vdp}
N 1930 470 1930 650 { lab=Vbn}
N 430 420 430 440 { lab=GND}
N 370 420 370 470 { lab=GND}
N 370 470 400 470 { lab=GND}
N 370 420 430 420 { lab=GND}
N 580 10 640 10 { lab=VDD}
N 550 40 550 60 { lab=VDD}
N 460 470 520 470 { lab=#net32}
N 460 10 520 10 { lab=VDD}
N 430 40 430 60 { lab=VDD}
N 430 60 550 60 { lab=VDD}
N 490 10 490 60 { lab=VDD}
N 370 60 430 60 { lab=VDD}
N 370 10 370 60 { lab=VDD}
N 370 10 400 10 { lab=VDD}
N 1030 500 1030 590 { lab=GND}
N 910 -110 910 -20 { lab=VDD}
N 1870 -40 1870 -20 { lab=VDD}
N 1870 -40 1930 -40 { lab=VDD}
N 1510 -110 1510 -20 { lab=VDD}
N 1390 500 1390 590 { lab=GND}
N 370 -110 370 10 { lab=VDD}
N 370 470 370 590 { lab=GND}
N 730 470 730 540 { lab=#net32}
N 730 540 730 550 { lab=#net32}
N 850 420 850 470 { lab=#net31}
N 610 420 610 470 { lab=#net31}
N 490 470 490 550 { lab=#net32}
N 550 420 1270 420 { lab=#net31}
N 1090 10 1090 110 { lab=#net34}
N 1350 10 1350 100 { lab=#net35}
N 1690 10 1690 70 { lab=#net36}
N 1210 470 1210 520 { lab=#net37}
N 1570 470 1570 500 { lab=#net38}
N 1810 470 1810 490 { lab=#net39}
N 700 250 760 250 { lab=#net33}
N 1060 250 1120 250 { lab=#net34}
N 1300 250 1360 250 { lab=#net35}
N 1660 250 1720 250 { lab=#net36}
N 1030 280 1030 300 { lab=Vdp}
N 1390 280 1390 300 { lab=Vdp}
N 1150 280 1150 300 { lab=Vdp}
N 1270 280 1270 300 { lab=Vdp}
N 670 280 670 330 { lab=Vbp}
N 1750 280 1750 330 { lab=Vbp}
N 1630 280 1630 330 { lab=Vbp}
N 790 280 790 330 { lab=Vbp}
N 610 130 610 250 { lab=VDD}
N 1810 130 1810 250 { lab=VDD}
N 1180 250 1240 250 { lab=VDD}
N 1210 130 1210 250 { lab=VDD}
N 1450 330 1450 470 { lab=Vbp}
N 820 250 880 250 { lab=#net31}
N 940 250 1000 250 { lab=Vdp}
N 850 250 850 420 { lab=#net31}
N 1540 250 1600 250 { lab=Vbn}
N 1570 250 1570 420 { lab=Vbn}
N 1420 250 1480 250 { lab=Vbp}
N 1450 250 1450 330 { lab=Vbp}
N 1330 300 1330 470 { lab=Vdp}
N 1780 250 1840 250 { lab=VDD}
N 1930 130 1930 250 { lab=VDD}
N 970 250 970 300 { lab=Vdp}
N 970 300 1390 300 { lab=Vdp}
N 580 250 640 250 { lab=VDD}
N 550 280 550 300 { lab=VDD}
N 460 250 520 250 { lab=VDD}
N 430 280 430 300 { lab=VDD}
N 430 300 550 300 { lab=VDD}
N 490 250 490 300 { lab=VDD}
N 370 300 430 300 { lab=VDD}
N 370 250 370 300 { lab=VDD}
N 370 250 400 250 { lab=VDD}
N 910 130 910 220 { lab=VDD}
N 1870 200 1870 220 { lab=VDD}
N 1870 200 1930 200 { lab=VDD}
N 1510 130 1510 220 { lab=VDD}
N 370 130 370 250 { lab=VDD}
N 1690 250 1690 310 { lab=#net36}
N 730 160 730 250 { lab=#net33}
N 1330 230 1330 300 { lab=Vdp}
N 910 -20 910 130 { lab=VDD}
N 670 330 790 330 { lab=Vbp}
N 320 130 1930 130 { lab=VDD}
N 850 180 850 250 { lab=#net31}
N 1450 230 1450 250 { lab=Vbp}
N 790 330 1750 330 { lab=Vbp}
N 1900 250 1930 250 { lab=VDD}
N 1570 180 1570 250 { lab=Vbn}
N 320 -110 1930 -110 { lab=VDD}
N 1900 10 1930 10 { lab=VDD}
N 1690 70 1690 250 { lab=#net36}
N 1090 110 1090 250 { lab=#net34}
N 1350 100 1350 250 { lab=#net35}
N 670 90 2000 90 { lab=Vbp}
N 910 670 910 690 { lab=#net31}
N 790 670 790 690 { lab=#net31}
N 670 670 670 690 { lab=#net31}
N 550 670 550 690 { lab=#net31}
N 580 720 640 720 { lab=#net31}
N 700 720 760 720 { lab=#net32}
N 820 720 880 720 { lab=#net31}
N 1150 670 1150 690 { lab=#net31}
N 1270 670 1270 690 { lab=#net31}
N 1180 720 1240 720 { lab=#net37}
N 1540 720 1600 720 { lab=#net38}
N 1780 720 1840 720 { lab=#net39}
N 1510 670 1510 690 { lab=Vbn}
N 1870 670 1870 690 { lab=Vbn}
N 1750 670 1750 690 { lab=Vbn}
N 1630 670 1630 690 { lab=Vbn}
N 1660 720 1720 720 { lab=GND}
N 1930 670 1930 720 { lab=Vbn}
N 1060 720 1120 720 { lab=GND}
N 940 720 1000 720 { lab=#net32}
N 1300 720 1360 720 { lab=Vdp}
N 1420 720 1480 720 { lab=Vbp}
N 430 670 430 690 { lab=GND}
N 370 670 370 720 { lab=GND}
N 370 720 400 720 { lab=GND}
N 370 670 430 670 { lab=GND}
N 460 720 520 720 { lab=#net32}
N 850 670 850 720 { lab=#net31}
N 610 670 610 720 { lab=#net31}
N 550 670 1270 670 { lab=#net31}
N 1510 670 1870 670 { lab=Vbn}
N 1870 670 1930 670 { lab=Vbn}
N 1900 720 1930 720 { lab=Vbn}
N 1930 650 1930 670 { lab=Vbn}
N 1690 590 1690 720 { lab=GND}
N 1390 590 1390 690 { lab=GND}
N 1570 500 1570 720 { lab=#net38}
N 1810 490 1810 720 { lab=#net39}
N 1210 520 1210 720 { lab=#net37}
N 730 550 730 720 { lab=#net32}
N 910 440 910 670 { lab=#net31}
N 1030 590 1030 690 { lab=GND}
N 970 550 970 720 { lab=#net32}
N 490 550 490 720 { lab=#net32}
N 1090 590 1090 720 { lab=GND}
N 790 440 790 670 { lab=#net31}
N 670 440 670 670 { lab=#net31}
N 550 440 550 670 { lab=#net31}
N 1150 440 1150 670 { lab=#net31}
N 1270 440 1270 670 { lab=#net31}
N 1510 440 1510 670 { lab=Vbn}
N 1630 440 1630 670 { lab=Vbn}
N 1750 440 1750 670 { lab=Vbn}
N 1870 440 1870 670 { lab=Vbn}
N 1990 -40 1990 -30 { lab=VDD}
N 1990 -30 1990 -20 { lab=VDD}
N 1930 -40 1990 -40 { lab=VDD}
N 1930 10 1960 10 { lab=VDD}
N 1930 -110 2020 -110 { lab=VDD}
N 2020 -110 2020 10 { lab=VDD}
N 1930 130 1930 250 { lab=VDD}
N 1990 200 1990 210 { lab=VDD}
N 1990 210 1990 220 { lab=VDD}
N 1930 200 1990 200 { lab=VDD}
N 1930 250 1960 250 { lab=VDD}
N 1930 130 2020 130 { lab=VDD}
N 2020 130 2020 250 { lab=VDD}
N 370 720 370 840 { lab=GND}
N 320 840 370 840 { lab=GND}
N 370 840 1930 840 { lab=GND}
N 1990 500 2020 500 { lab=GND}
N 2020 470 2020 500 { lab=GND}
N 2020 500 2020 550 { lab=GND}
N 1930 720 1960 720 { lab=Vbn}
N 1990 750 2020 750 { lab=GND}
N 2020 720 2020 750 { lab=GND}
N 1930 840 2020 840 { lab=GND}
N 2020 750 2020 840 { lab=GND}
N 1510 420 1930 420 { lab=Vbn}
N 320 590 2020 590 { lab=GND}
N 2020 550 2020 590 { lab=GND}
N 320 550 970 550 { lab=#net32}
N 1450 470 1450 720 { lab=Vbp}
N 1330 470 1330 720 { lab=Vdp}
N 730 10 730 160 { lab=#net33}
N 1930 670 2060 670 { lab=Vbn}
N 2060 670 2750 670 { lab=Vbn}
N 2750 670 2750 790 { lab=Vbn}
N 2000 90 2190 90 { lab=Vbp}
N 240 550 320 550 { lab=#net32}
N -1360 2560 -1360 2580 { lab=CLK}
N -1640 2580 -1360 2580 { lab=CLK}
N -1330 2470 -1300 2470 { lab=Q0}
N -1310 2440 -1310 2470 { lab=Q0}
N -1210 2520 -1150 2520 { lab=Qn0}
N -1150 2380 -1150 2520 { lab=Qn0}
N -1450 2380 -1150 2380 { lab=Qn0}
N -1450 2380 -1450 2470 { lab=Qn0}
N -1450 2470 -1420 2470 { lab=Qn0}
N -1240 2560 -1240 2580 { lab=#net40}
N -1240 2680 -1240 2700 { lab=CLK}
N -1360 2700 -1240 2700 { lab=CLK}
N -1360 2580 -1360 2700 { lab=CLK}
N -960 2470 -930 2470 { lab=Q1}
N -840 2520 -780 2520 { lab=Qn1}
N -780 2380 -780 2520 { lab=Qn1}
N -1080 2380 -780 2380 { lab=Qn1}
N -1080 2380 -1080 2470 { lab=Qn1}
N -1080 2470 -1050 2470 { lab=Qn1}
N -590 2470 -560 2470 { lab=Q2}
N -470 2520 -410 2520 { lab=Qn2}
N -410 2380 -410 2520 { lab=Qn2}
N -710 2380 -410 2380 { lab=Qn2}
N -710 2380 -710 2470 { lab=Qn2}
N -710 2470 -680 2470 { lab=Qn2}
N -220 2470 -190 2470 { lab=Q3}
N -100 2520 -40 2520 { lab=Qn3}
N -40 2380 -40 2520 { lab=Qn3}
N -340 2380 -40 2380 { lab=Qn3}
N -340 2380 -340 2470 { lab=Qn3}
N -340 2470 -310 2470 { lab=Qn3}
N 150 2470 180 2470 { lab=Q4}
N 270 2520 330 2520 { lab=Qn4}
N 330 2380 330 2520 { lab=Qn4}
N 30 2380 330 2380 { lab=Qn4}
N 30 2380 30 2470 { lab=Qn4}
N 30 2470 60 2470 { lab=Qn4}
N -940 2340 -940 2470 { lab=Q1}
N -580 2340 -580 2470 { lab=Q2}
N -210 2340 -210 2470 { lab=Q3}
N 160 2340 160 2470 { lab=Q4}
N -870 2560 -870 2700 { lab=0clk}
N -1150 2700 -870 2700 { lab=0clk}
N -990 2660 -990 2700 { lab=0clk}
N -500 2560 -500 2700 { lab=1clk}
N -780 2700 -500 2700 { lab=1clk}
N -620 2660 -620 2700 { lab=1clk}
N -130 2560 -130 2700 { lab=2clk}
N -410 2700 -130 2700 { lab=2clk}
N -250 2660 -250 2700 { lab=2clk}
N 240 2560 240 2700 { lab=3clk}
N -40 2700 240 2700 { lab=3clk}
N 120 2660 120 2700 { lab=3clk}
N 540 2470 570 2470 { lab=Q5}
N 660 2520 720 2520 { lab=Qn5}
N 720 2380 720 2520 { lab=Qn5}
N 420 2380 720 2380 { lab=Qn5}
N 420 2380 420 2470 { lab=Qn5}
N 420 2470 450 2470 { lab=Qn5}
N 910 2470 940 2470 { lab=Q6}
N 1030 2520 1090 2520 { lab=Qn6}
N 1090 2380 1090 2520 { lab=Qn6}
N 790 2380 1090 2380 { lab=Qn6}
N 790 2380 790 2470 { lab=Qn6}
N 790 2470 820 2470 { lab=Qn6}
N 550 2340 550 2470 { lab=Q5}
N 920 2340 920 2470 { lab=Q6}
N 630 2560 630 2700 { lab=4clk}
N 350 2700 630 2700 { lab=4clk}
N 510 2660 510 2700 { lab=4clk}
N 1000 2560 1000 2700 { lab=5clk}
N 720 2700 1000 2700 { lab=5clk}
N 880 2660 880 2700 { lab=5clk}
N 1420 -340 1570 -340 { lab=#net41}
N 1900 1190 1900 1220 {}
N 1870 1190 1900 1190 {}
N 1760 1220 1900 1220 {}
N 1730 1170 1730 1190 {}
N 1730 1180 1780 1180 {}
N 1780 1140 1780 1180 {}
N 1760 1140 1780 1140 {}
C {madvlsi/vsource.sym} 320 -780 0 0 {name=Vdd
value=1.8}
C {madvlsi/gnd.sym} 320 -750 0 0 {name=l23 lab=GND}
C {madvlsi/vdd.sym} 320 -810 0 0 {name=l26 lab=VDD}
C {madvlsi/vsource.sym} 420 -790 0 0 {name=VCLK
value="pulse(0 1.8 0u 1m 1m 5m 10m)"}
C {madvlsi/gnd.sym} 420 -760 0 0 {name=l22 lab=GND}
C {devices/lab_pin.sym} 420 -820 0 0 {name=l25 sig_type=std_logic lab=CLK}
C {madvlsi/vsource.sym} 210 -780 0 0 {name=Vdd2
value=0.2}
C {madvlsi/gnd.sym} 210 -750 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} 210 -810 1 0 {name=l14 sig_type=std_logic lab=Vin}
C {devices/code_shown.sym} 1130 2260 0 0 {name=SPICE only_toplevel=false value=".ic v(Q0)=0 v(Qn0)=1.8
.ic v(Q1)=0 v(Qn1)=1.8
.ic v(Q2)=0 v(Qn2)=1.8
.ic v(Q3)=0 v(Qn3)=1.8
.ic v(Q4)=0 v(Qn4)=1.8
.ic v(Q5)=0 v(Qn5)=1.8
.ic v(Q6)=0 v(Qn6)=1.8
.tran 4m 1000m
.save all"}
C {madvlsi/tt_models.sym} 120 -620 0 0 {
name=TT_MODELS
only_toplevel=false
value=".option wnflag=1
.param MC_SWITCH=0.0
.lib ~/skywater/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/sky130.lib.spice tt"
}
C {madvlsi/resistor.sym} 180 580 0 0 {name=R1
value=400k
m=1}
C {madvlsi/ammeter1.sym} 240 550 1 1 {name=vbias}
C {madvlsi/gnd.sym} 180 610 0 0 {name=l2 lab=GND}
C {madvlsi/nmos3.sym} 3710 700 3 0 {name=M60
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3710 470 3 0 {name=M61
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3710 360 3 0 {name=M62
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3710 590 1 0 {name=M63
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 3660 330 0 0 {name=l3 lab=VDD}
C {madvlsi/nmos3.sym} 4110 700 3 0 {name=Mdumb64
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4110 470 3 0 {name=Mdumb65
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4110 360 3 0 {name=Mdumb66
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4110 590 3 0 {name=Mdumb67
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3610 700 3 0 {name=Mdumb68
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3610 470 3 0 {name=Mdumb69
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3610 360 3 0 {name=Mdumb70
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3610 590 3 0 {name=Mdumb71
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 4140 620 0 0 {name=l4 lab=GND}
C {madvlsi/gnd.sym} 4140 730 0 0 {name=l5 lab=GND}
C {madvlsi/gnd.sym} 4140 390 0 0 {name=l6 lab=GND}
C {madvlsi/gnd.sym} 4140 500 0 0 {name=l7 lab=GND}
C {madvlsi/gnd.sym} 3580 730 0 0 {name=l8 lab=GND}
C {madvlsi/gnd.sym} 3580 620 0 0 {name=l9 lab=GND}
C {madvlsi/gnd.sym} 3580 500 0 0 {name=l10 lab=GND}
C {madvlsi/gnd.sym} 3580 390 0 0 {name=l15 lab=GND}
C {madvlsi/nmos3.sym} 3810 700 3 0 {name=M59
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3810 470 3 0 {name=M72
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3810 360 3 0 {name=M73
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3810 590 1 0 {name=M74
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3910 700 3 0 {name=M75
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3910 470 3 0 {name=M64
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3910 360 3 0 {name=M65
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3910 590 1 0 {name=M66
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4010 700 3 0 {name=M67
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4010 470 3 0 {name=M68
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4010 360 3 0 {name=M69
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4010 590 1 0 {name=M70
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 4060 330 0 0 {name=l17 lab=VDD}
C {madvlsi/gnd.sym} 4060 700 0 0 {name=l38 lab=GND}
C {madvlsi/gnd.sym} 3660 700 0 0 {name=l39 lab=GND}
C {madvlsi/pmos3.sym} 3020 470 1 0 {name=M76
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3120 470 1 0 {name=M77
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3220 470 1 0 {name=M78
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3320 470 1 0 {name=M79
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3020 360 3 0 {name=M80
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3120 360 3 0 {name=M81
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3220 360 3 0 {name=M82
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3320 360 3 0 {name=M83
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 3170 750 0 0 {name=l57 lab=GND}
C {madvlsi/vdd.sym} 3170 330 0 0 {name=l58 lab=VDD}
C {madvlsi/pmos3.sym} 2920 470 1 0 {name=Mdumb45
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2920 360 1 0 {name=Mdumb46
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3420 470 1 0 {name=Mdumb47
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3420 360 1 0 {name=Mdumb48
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2920 590 3 0 {name=Mdumb49
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2920 700 3 0 {name=Mdumb84
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2890 730 0 0 {name=l59 lab=GND}
C {madvlsi/gnd.sym} 2890 620 0 0 {name=l60 lab=GND}
C {madvlsi/vdd.sym} 2890 330 0 0 {name=l61 lab=VDD}
C {madvlsi/vdd.sym} 2890 440 0 0 {name=l62 lab=VDD}
C {madvlsi/gnd.sym} 3450 620 0 0 {name=l63 lab=GND}
C {madvlsi/gnd.sym} 3450 730 0 0 {name=l64 lab=GND}
C {madvlsi/vdd.sym} 3450 440 0 0 {name=l65 lab=VDD}
C {madvlsi/vdd.sym} 3450 330 0 0 {name=l66 lab=VDD}
C {madvlsi/nmos3.sym} 3020 590 3 0 {name=M51
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3020 700 3 0 {name=M52
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3120 590 3 0 {name=M53
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3120 700 3 0 {name=M54
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3220 590 3 0 {name=M55
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3220 700 1 0 {name=M56
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3320 590 3 0 {name=M57
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3320 700 1 0 {name=M58
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3420 590 3 0 {name=Mdumb85
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3420 700 3 0 {name=Mdumb60
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 4230 530 2 0 {name=l67 sig_type=std_logic lab=Vg}
C {madvlsi/capacitor.sym} 2100 120 0 0 {name=C1
value=10p
m=1}
C {madvlsi/gnd.sym} 2100 150 0 0 {name=l68 lab=GND}
C {madvlsi/nmos3.sym} -260 1120 1 0 {name=M50
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -160 1120 1 0 {name=M71
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -60 1120 1 0 {name=Mdumb72
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 40 1120 1 0 {name=M84
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 140 1120 1 0 {name=Mdumb86
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 240 1120 1 0 {name=M87
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 340 1120 1 0 {name=Mdumb88
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 440 1120 1 0 {name=M89
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 540 1120 1 0 {name=Mdumb90
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 640 1120 1 0 {name=M91
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 740 1120 1 0 {name=Mdumb92
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 840 1120 1 0 {name=M93
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 940 1120 1 0 {name=Mdumb94
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1040 1120 1 0 {name=M95
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1140 1120 1 0 {name=M96
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -260 1350 1 0 {name=M97
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -160 1350 1 0 {name=M98
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -60 1350 1 0 {name=M99
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 40 1350 1 0 {name=M100
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 140 1350 1 0 {name=Mdumb101
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 240 1350 1 0 {name=M102
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 340 1350 1 0 {name=M103
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 440 1350 1 0 {name=M104
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 540 1350 1 0 {name=M105
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 640 1350 1 0 {name=Mdumb106
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 740 1350 1 0 {name=M107
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 840 1350 1 0 {name=M108
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 940 1350 1 0 {name=M109
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1040 1350 1 0 {name=M110
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -60 1560 3 0 {name=M111
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 40 1560 3 0 {name=Mdumb112
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 140 1560 3 0 {name=M113
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 240 1560 3 0 {name=M114
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 340 1560 3 0 {name=Mdumb115
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 440 1560 3 0 {name=M116
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 540 1560 3 0 {name=M117
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 640 1560 3 0 {name=Mdumb118
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 740 1560 3 0 {name=M119
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 840 1560 3 0 {name=M120
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1240 1120 1 0 {name=Mdumb121
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1340 1120 1 0 {name=Mdumb122
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -360 1120 1 0 {name=Mdumb123
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -460 1120 1 0 {name=Mdumb124
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -360 1350 1 0 {name=Mdumb125
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -460 1350 1 0 {name=Mdumb126
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1140 1350 1 0 {name=Mdumb127
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1240 1350 1 0 {name=Mdumb128
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1340 1350 1 0 {name=M129
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 940 1560 3 0 {name=Mdumb130
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1040 1560 3 0 {name=Mdumb131
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1140 1560 3 0 {name=Mdumb132
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1240 1560 3 0 {name=Mdumb133
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1340 1560 3 0 {name=Mdumb134
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -160 1560 3 0 {name=Mdumb135
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -260 1560 3 0 {name=Mdumb136
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -360 1560 3 0 {name=Mdumb137
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -460 1560 3 0 {name=Mdumb138
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1390 1060 2 0 {name=l69 sig_type=std_logic lab=Vg}
C {madvlsi/vdd.sym} -530 940 0 0 {name=l70 lab=VDD}
C {madvlsi/gnd.sym} -510 1700 0 0 {name=l71 lab=GND}
C {madvlsi/gnd.sym} -200 1860 0 0 {name=l72 lab=GND}
C {madvlsi/gnd.sym} 10 1860 0 0 {name=l73 lab=GND}
C {devices/lab_pin.sym} -240 1900 0 0 {name=l76 sig_type=std_logic lab=Vbn}
C {madvlsi/gnd.sym} 220 1860 0 0 {name=l79 lab=GND}
C {madvlsi/gnd.sym} 410 1860 0 0 {name=l82 lab=GND}
C {madvlsi/gnd.sym} 600 1860 0 0 {name=l86 lab=GND}
C {madvlsi/gnd.sym} 790 1860 0 0 {name=l91 lab=GND}
C {madvlsi/gnd.sym} 980 1860 0 0 {name=l95 lab=GND}
C {devices/lab_pin.sym} -60 1700 3 0 {name=l100 sig_type=std_logic lab=b0}
C {devices/lab_pin.sym} 240 1690 3 0 {name=l102 sig_type=std_logic lab=b2}
C {devices/lab_pin.sym} 140 1690 3 0 {name=l103 sig_type=std_logic lab=b1}
C {devices/lab_pin.sym} 740 1690 3 0 {name=l104 sig_type=std_logic lab=b5}
C {devices/lab_pin.sym} 440 1690 3 0 {name=l105 sig_type=std_logic lab=b3}
C {devices/lab_pin.sym} 540 1690 3 0 {name=l106 sig_type=std_logic lab=b4}
C {devices/lab_pin.sym} 840 1690 3 0 {name=l107 sig_type=std_logic lab=b6}
C {madvlsi/pmos3.sym} 2750 1140 3 0 {name=M140
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2850 1140 3 0 {name=M2a
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2950 1140 3 0 {name=M141
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3050 1140 3 0 {name=M4a
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3150 1140 3 0 {name=M5a
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3250 1140 3 0 {name=M5b
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3350 1140 3 0 {name=M4b
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3450 1140 3 0 {name=M142
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3550 1140 3 0 {name=M2b
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3650 1140 3 0 {name=M143
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2650 1140 3 0 {name=M1a
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3750 1140 3 0 {name=M1b
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2550 1140 3 0 {name=M144
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3850 1140 3 0 {name=M145
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 2070 950 0 0 {name=l116 lab=VDD}
C {madvlsi/pmos3.sym} 3950 1140 3 0 {name=M146
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4050 1140 3 0 {name=M147
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2450 1140 3 0 {name=M148
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2350 1140 3 0 {name=M149
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2250 1140 3 0 {name=M150
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2260 1750 1 0 {name=M151
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2360 1750 1 0 {name=M152
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2460 1750 1 0 {name=Mdumb153
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2560 1750 1 0 {name=M154
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2660 1750 1 0 {name=Mdumb155
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2760 1750 1 0 {name=M156
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2860 1750 1 0 {name=Mdumb34
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2960 1750 1 0 {name=M157
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3060 1750 1 0 {name=Mdumb37
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3160 1750 1 0 {name=M158
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3260 1750 1 0 {name=Mdumb40
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3360 1750 1 0 {name=M159
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3460 1750 1 0 {name=Mdumb43
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3560 1750 1 0 {name=M160
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3660 1750 1 0 {name=M161
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2260 1980 1 0 {name=M162
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2360 1980 1 0 {name=M163
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2460 1980 1 0 {name=M164
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2560 1980 1 0 {name=M165
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2660 1980 1 0 {name=Mdumb166
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2760 1980 1 0 {name=M167
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2860 1980 1 0 {name=M168
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2960 1980 1 0 {name=M169
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3060 1980 1 0 {name=M170
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3160 1980 1 0 {name=Mdumb171
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3260 1980 1 0 {name=M172
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3360 1980 1 0 {name=M173
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3460 1980 1 0 {name=M174
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3560 1980 1 0 {name=M175
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2460 2190 3 0 {name=M176
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2560 2190 3 0 {name=Mdumb177
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2660 2190 3 0 {name=M178
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2760 2190 3 0 {name=M179
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2860 2190 3 0 {name=Mdumb180
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2960 2190 3 0 {name=M181
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3060 2190 3 0 {name=M182
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3160 2190 3 0 {name=Mdumb183
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3260 2190 3 0 {name=M184
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3360 2190 3 0 {name=M185
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3760 1750 1 0 {name=Mdumb74
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3860 1750 1 0 {name=Mdumb75
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2160 1750 1 0 {name=Mdumb76
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2060 1750 1 0 {name=Mdumb77
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2160 1980 1 0 {name=Mdumb78
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2060 1980 1 0 {name=Mdumb79
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3660 1980 1 0 {name=Mdumb80
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3760 1980 1 0 {name=Mdumb81
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3860 1980 1 0 {name=M186
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3460 2190 3 0 {name=Mdumb83
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3560 2190 3 0 {name=Mdumb187
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3660 2190 3 0 {name=Mdumb188
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3760 2190 3 0 {name=Mdumb189
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3860 2190 3 0 {name=Mdumb87
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2360 2190 3 0 {name=Mdumb190
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2260 2190 3 0 {name=Mdumb89
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2160 2190 3 0 {name=Mdumb191
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2060 2190 3 0 {name=Mdumb91
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 3910 1690 2 0 {name=l118 sig_type=std_logic lab=Vg}
C {madvlsi/vdd.sym} 1990 1570 0 0 {name=l119 lab=VDD}
C {madvlsi/gnd.sym} 2010 2330 0 0 {name=l120 lab=GND}
C {madvlsi/ammeter1.sym} 1700 1040 1 0 {name=VIl}
C {devices/lab_pin.sym} 2460 2220 3 0 {name=l121 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} 4230 790 2 0 {name=l85 sig_type=std_logic lab=Vbn}
C {devices/lab_pin.sym} 1940 1220 1 0 {name=l88 sig_type=std_logic lab=Vout_dac}
C {devices/lab_pin.sym} 2190 90 2 0 {name=l89 sig_type=std_logic lab=Vbp}
C {madvlsi/nmos3.sym} 550 470 1 0 {name=M5
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 670 470 1 0 {name=M7
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 790 470 1 0 {name=M9
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 910 470 1 0 {name=M11
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1150 470 1 0 {name=M13
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1270 470 1 0 {name=M30
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1510 470 1 0 {name=M35
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1630 470 1 0 {name=M37
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1750 470 1 0 {name=M38
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1870 470 1 0 {name=M40
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 670 10 1 1 {name=M41
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 790 10 1 1 {name=M43
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1030 10 1 1 {name=M44
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1150 10 1 1 {name=M1
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1270 10 1 1 {name=M2
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1390 10 1 1 {name=M3
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1630 10 1 1 {name=M85
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1750 10 1 1 {name=M86
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 910 10 3 1 {name=Mdumb4
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1510 10 3 1 {name=Mdumb5
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1030 470 3 0 {name=Mdumb6
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1390 470 3 0 {name=Mdumb7
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1870 10 3 1 {name=Mdumb113
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 320 590 1 0 {name=l93 lab=GND}
C {madvlsi/vdd.sym} 320 -110 3 0 {name=l96 lab=VDD}
C {madvlsi/nmos3.sym} 430 470 1 0 {name=Mdumb8
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 550 10 1 1 {name=Mdumb119
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 430 10 1 1 {name=Mdumb120
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1330 60 1 0 {name=l97 sig_type=std_logic lab=Vdp}
C {madvlsi/pmos3.sym} 670 250 1 1 {name=M10
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 790 250 1 1 {name=M88
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1030 250 1 1 {name=M12
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1150 250 1 1 {name=M90
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1270 250 1 1 {name=M101
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1390 250 1 1 {name=M14
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1630 250 1 1 {name=M15
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1750 250 1 1 {name=M112
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 910 250 3 1 {name=Mdumb16
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1510 250 3 1 {name=Mdumb17
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1870 250 3 1 {name=Mdumb18
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 320 130 3 0 {name=l101 lab=VDD}
C {madvlsi/pmos3.sym} 550 250 1 1 {name=Mdumb19
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 430 250 1 1 {name=Mdumb20
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 550 720 1 0 {name=M21
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 670 720 1 0 {name=M22
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 790 720 1 0 {name=M23
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 910 720 1 0 {name=M106
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1150 720 1 0 {name=M24
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1270 720 1 0 {name=M25
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1510 720 1 0 {name=M26
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1630 720 1 0 {name=M27
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1750 720 1 0 {name=M28
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1870 720 1 0 {name=M29
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1030 720 1 0 {name=Mdumb30
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1390 720 1 0 {name=Mdumb116
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 320 840 1 0 {name=l108 lab=GND}
C {madvlsi/nmos3.sym} 430 720 1 0 {name=Mdumb31
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1990 10 3 1 {name=Mdumb1
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1990 250 3 1 {name=Mdumb2
L=4.0
W=16
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1990 720 3 0 {name=Mdumb3
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1990 470 3 0 {name=Mdumb32
L=4.0
W=16
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -170 2010 3 0 {name=l74 sig_type=std_logic lab=Q0}
C {devices/lab_pin.sym} 40 2010 3 0 {name=l75 sig_type=std_logic lab=Q1}
C {devices/lab_pin.sym} 250 2010 3 0 {name=l80 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 440 2010 3 0 {name=l83 sig_type=std_logic lab=Q3}
C {devices/lab_pin.sym} 630 2010 3 0 {name=l87 sig_type=std_logic lab=Q4}
C {devices/lab_pin.sym} 820 2010 3 0 {name=l92 sig_type=std_logic lab=Q5}
C {devices/lab_pin.sym} 1010 2010 3 0 {name=l109 sig_type=std_logic lab=Q6}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/mux2.sym} -220 1820 3 0 {name=X1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/mux2.sym} -10 1820 3 0 {name=X2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/mux2.sym} 200 1820 3 0 {name=X3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/mux2.sym} 390 1820 3 0 {name=X5}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/mux2.sym} 580 1820 3 0 {name=X6}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/mux2.sym} 770 1820 3 0 {name=X9}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/mux2.sym} 960 1820 3 0 {name=X10}
C {devices/lab_pin.sym} -1310 2440 1 0 {name=l40 sig_type=std_logic lab=Q0}
C {devices/lab_pin.sym} -1640 2580 0 0 {name=l1 sig_type=std_logic lab=CLK}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} -1470 2500 0 0 {name=X4}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} -1350 2500 0 0 {name=X7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -1240 2640 3 0 {name=X8 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} -1280 2640 3 0 {name=l16 lab=VDD}
C {madvlsi/gnd.sym} -1200 2640 3 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} -940 2340 1 0 {name=l19 sig_type=std_logic lab=Q1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} -1100 2500 0 0 {name=X11}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} -980 2500 0 0 {name=X12}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -990 2620 3 0 {name=X15 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} -1030 2620 3 0 {name=l20 lab=VDD}
C {madvlsi/gnd.sym} -950 2620 3 0 {name=l21 lab=GND}
C {devices/lab_pin.sym} -1150 2520 2 0 {name=l24 sig_type=std_logic lab=Qn0}
C {devices/lab_pin.sym} -780 2520 2 0 {name=l27 sig_type=std_logic lab=Qn1}
C {devices/lab_pin.sym} -580 2340 1 0 {name=l28 sig_type=std_logic lab=Q2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} -730 2500 0 0 {name=X16}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} -610 2500 0 0 {name=X19}
C {devices/lab_pin.sym} -410 2520 2 0 {name=l29 sig_type=std_logic lab=Qn2}
C {devices/lab_pin.sym} -210 2340 1 0 {name=l30 sig_type=std_logic lab=Q3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} -360 2500 0 0 {name=X23}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} -240 2500 0 0 {name=X24}
C {devices/lab_pin.sym} -40 2520 2 0 {name=l31 sig_type=std_logic lab=Qn3}
C {devices/lab_pin.sym} 160 2340 1 0 {name=l32 sig_type=std_logic lab=Q4}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 10 2500 0 0 {name=X25}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 130 2500 0 0 {name=X26}
C {devices/lab_pin.sym} 330 2520 2 0 {name=l33 sig_type=std_logic lab=Qn4}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -620 2620 3 0 {name=X27 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} -660 2620 3 0 {name=l34 lab=VDD}
C {madvlsi/gnd.sym} -580 2620 3 0 {name=l35 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -250 2620 3 0 {name=X28 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} -290 2620 3 0 {name=l36 lab=VDD}
C {madvlsi/gnd.sym} -210 2620 3 0 {name=l37 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 120 2620 3 0 {name=X29 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 80 2620 3 0 {name=l41 lab=VDD}
C {madvlsi/gnd.sym} 160 2620 3 0 {name=l42 lab=GND}
C {devices/lab_pin.sym} -1330 2520 2 0 {name=l43 sig_type=std_logic lab=0clk}
C {devices/lab_pin.sym} -960 2520 2 0 {name=l44 sig_type=std_logic lab=1clk}
C {devices/lab_pin.sym} -590 2520 2 0 {name=l45 sig_type=std_logic lab=2clk}
C {devices/lab_pin.sym} -220 2520 2 0 {name=l46 sig_type=std_logic lab=3clk}
C {devices/lab_pin.sym} 150 2520 2 0 {name=l47 sig_type=std_logic lab=4clk}
C {devices/lab_pin.sym} -1150 2700 0 0 {name=l48 sig_type=std_logic lab=0clk}
C {devices/lab_pin.sym} -780 2700 0 0 {name=l49 sig_type=std_logic lab=1clk}
C {devices/lab_pin.sym} -410 2700 0 0 {name=l50 sig_type=std_logic lab=2clk}
C {devices/lab_pin.sym} -40 2700 0 0 {name=l51 sig_type=std_logic lab=3clk}
C {devices/lab_pin.sym} 550 2340 1 0 {name=l52 sig_type=std_logic lab=Q5}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 400 2500 0 0 {name=X30}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 520 2500 0 0 {name=X31}
C {devices/lab_pin.sym} 720 2520 2 0 {name=l53 sig_type=std_logic lab=Qn5}
C {devices/lab_pin.sym} 920 2340 1 0 {name=l54 sig_type=std_logic lab=Q6}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 770 2500 0 0 {name=X32}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 890 2500 0 0 {name=X33}
C {devices/lab_pin.sym} 1090 2520 2 0 {name=l99 sig_type=std_logic lab=Qn6}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 510 2620 3 0 {name=X34 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 470 2620 3 0 {name=l110 lab=VDD}
C {madvlsi/gnd.sym} 550 2620 3 0 {name=l111 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 880 2620 3 0 {name=X35 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 840 2620 3 0 {name=l115 lab=VDD}
C {madvlsi/gnd.sym} 920 2620 3 0 {name=l117 lab=GND}
C {devices/lab_pin.sym} 540 2520 2 0 {name=l122 sig_type=std_logic lab=5clk}
C {devices/lab_pin.sym} 910 2520 2 0 {name=l123 sig_type=std_logic lab=6clk}
C {devices/lab_pin.sym} 350 2700 0 0 {name=l124 sig_type=std_logic lab=4clk}
C {devices/lab_pin.sym} 720 2700 0 0 {name=l125 sig_type=std_logic lab=5clk}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/diff_amp.sym} 1540 -370 0 0 {name=X13}
C {devices/lab_pin.sym} 1570 -400 0 0 {name=l55 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 1420 -340 0 0 {name=l56 sig_type=std_logic lab=Vout_pmos}
C {madvlsi/isource.sym} 1590 -290 1 0 {name=I1
value=1u}
C {madvlsi/gnd.sym} 1560 -290 0 0 {name=l77 lab=GND}
C {madvlsi/vdd.sym} 1650 -470 0 0 {name=l78 lab=VDD}
C {madvlsi/gnd.sym} 1650 -270 0 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} 1750 -370 2 0 {name=l90 sig_type=std_logic lab=Vout}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} -170 1970 3 0 {name=X17 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} -210 1970 3 0 {name=l112 lab=VDD}
C {madvlsi/gnd.sym} -130 1970 3 0 {name=l113 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 40 1970 3 0 {name=X18 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 0 1970 3 0 {name=l114 lab=VDD}
C {madvlsi/gnd.sym} 80 1970 3 0 {name=l126 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 250 1970 3 0 {name=X20 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 210 1970 3 0 {name=l127 lab=VDD}
C {madvlsi/gnd.sym} 290 1970 3 0 {name=l128 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 440 1970 3 0 {name=X21 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 400 1970 3 0 {name=l129 lab=VDD}
C {madvlsi/gnd.sym} 480 1970 3 0 {name=l130 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 630 1970 3 0 {name=X22 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 590 1970 3 0 {name=l131 lab=VDD}
C {madvlsi/gnd.sym} 670 1970 3 0 {name=l132 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 820 1970 3 0 {name=X36 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 780 1970 3 0 {name=l133 lab=VDD}
C {madvlsi/gnd.sym} 860 1970 3 0 {name=l134 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 1010 1970 3 0 {name=X37 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 970 1970 3 0 {name=l135 lab=VDD}
C {madvlsi/gnd.sym} 1050 1970 3 0 {name=l136 lab=GND}
C {madvlsi/nmos3.sym} 1870 1220 2 0 {name=Mdumb9
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1870 1250 0 0 {name=l11 lab=GND}
C {madvlsi/nmos3.sym} 1730 1220 2 0 {name=Mdumb10
L=4
W=64
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1730 1250 0 0 {name=l12 lab=GND}
C {madvlsi/pmos3.sym} 1730 1140 2 0 {name=M4
L=4
W=64
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1780 1140 2 0 {name=l84 sig_type=std_logic lab=Vout_pmos}
C {madvlsi/vdd.sym} 1730 1110 0 0 {name=l94 lab=VDD}
