v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 420 -500 450 -500 { lab=Q0}
N 450 -560 450 -500 { lab=Q0}
N 460 -500 480 -500 { lab=#net1}
N 460 -560 460 -500 { lab=#net1}
N 330 -560 330 -500 { lab=#net2}
N 430 -560 430 -450 { lab=Qn0}
N 580 -560 580 -450 { lab=Qn1}
N 570 -450 580 -450 { lab=Qn1}
N 570 -500 600 -500 { lab=Q1}
N 600 -560 600 -500 { lab=Q1}
N 420 -450 430 -450 { lab=Qn0}
N 430 -450 450 -450 { lab=Qn0}
N 450 -450 450 -390 { lab=Qn0}
N 540 -410 540 -390 { lab=#net3}
N 580 -450 600 -450 { lab=Qn1}
N 600 -450 600 -390 { lab=Qn1}
N 700 -500 730 -500 { lab=Q2}
N 730 -560 730 -500 { lab=Q2}
N 740 -500 760 -500 { lab=#net4}
N 740 -560 740 -500 { lab=#net4}
N 610 -560 610 -500 { lab=#net5}
N 710 -560 710 -450 { lab=Qn2}
N 860 -560 860 -450 { lab=Qn3}
N 850 -450 860 -450 { lab=Qn3}
N 850 -500 880 -500 { lab=Q3}
N 880 -560 880 -500 { lab=Q3}
N 700 -450 710 -450 { lab=Qn2}
N 710 -450 730 -450 { lab=Qn2}
N 730 -450 730 -390 { lab=Qn2}
N 820 -410 820 -390 { lab=#net6}
N 860 -450 880 -450 { lab=Qn3}
N 880 -450 880 -390 { lab=Qn3}
N 670 -410 670 -390 { lab=#net7}
N 950 -410 950 -390 { lab=#net8}
N 980 -500 1010 -500 { lab=Q4}
N 1010 -560 1010 -500 { lab=Q4}
N 1020 -500 1040 -500 { lab=#net9}
N 1020 -560 1020 -500 { lab=#net9}
N 890 -560 890 -500 { lab=#net10}
N 990 -560 990 -450 { lab=Qn4}
N 1140 -560 1140 -450 { lab=Qn5}
N 1130 -450 1140 -450 { lab=Qn5}
N 1130 -500 1160 -500 { lab=Q5}
N 1160 -560 1160 -500 { lab=Q5}
N 980 -450 990 -450 { lab=Qn4}
N 990 -450 1010 -450 { lab=Qn4}
N 1010 -450 1010 -390 { lab=Qn4}
N 1100 -410 1100 -390 { lab=#net11}
N 1140 -450 1160 -450 { lab=Qn5}
N 1160 -450 1160 -390 { lab=Qn5}
N 1260 -500 1290 -500 { lab=Q6}
N 1290 -560 1290 -500 { lab=Q6}
N 1170 -560 1170 -500 { lab=#net12}
N 1270 -560 1270 -450 { lab=Qn6}
N 1260 -450 1270 -450 { lab=Qn6}
N 1270 -450 1290 -450 { lab=Qn6}
N 1230 -410 1230 -390 { lab=#net13}
N 390 -410 390 -390 { lab=CLK}
N 110 -390 390 -390 { lab=CLK}
N 480 -450 570 -500 { lab=Q1}
N 330 -450 420 -500 { lab=Q0}
N 610 -450 700 -500 { lab=Q2}
N 760 -450 850 -500 { lab=Q3}
N 890 -450 980 -500 { lab=Q4}
N 1040 -450 1130 -500 { lab=Q5}
N 1170 -450 1260 -500 { lab=Q6}
N 450 -290 540 -290 { lab=#net3}
N 540 -390 540 -290 { lab=#net3}
N 670 -390 670 -290 { lab=#net7}
N 600 -290 670 -290 { lab=#net7}
N 730 -290 820 -290 { lab=#net6}
N 820 -390 820 -290 { lab=#net6}
N 1010 -290 1100 -290 { lab=#net11}
N 1100 -390 1100 -290 { lab=#net11}
N 1230 -390 1230 -290 { lab=#net13}
N 1160 -290 1230 -290 { lab=#net13}
N 950 -390 950 -290 { lab=#net8}
N 880 -290 950 -290 { lab=#net8}
N 560 -560 580 -560 { lab=Qn1}
N 840 -560 860 -560 { lab=Qn3}
N 1120 -560 1140 -560 { lab=Qn5}
N 330 200 330 230 { lab=#net14}
N 330 230 510 230 { lab=#net14}
N 510 200 510 230 { lab=#net14}
N 510 140 510 180 { lab=Q0s}
N 540 200 540 230 { lab=#net15}
N 540 230 720 230 { lab=#net15}
N 720 200 720 230 { lab=#net15}
N 510 200 540 180 { lab=#net14}
N 720 140 720 180 { lab=Q1s}
N 720 200 750 180 { lab=#net15}
N 750 200 750 230 { lab=#net16}
N 750 230 930 230 { lab=#net16}
N 930 200 930 230 { lab=#net16}
N 930 140 930 180 { lab=Q2s}
N 960 200 960 230 { lab=#net17}
N 960 230 1140 230 { lab=#net17}
N 1140 200 1140 230 { lab=#net17}
N 930 200 960 180 { lab=#net16}
N 1140 140 1140 180 { lab=Q3b}
N 1140 200 1170 180 { lab=#net17}
C {devices/lab_pin.sym} 110 -390 0 0 {name=l10 sig_type=std_logic lab=CLK}
C {madvlsi/vsource.sym} 240 -130 0 0 {name=Vdd
value=1.8}
C {madvlsi/gnd.sym} 240 -100 0 0 {name=l23 lab=GND}
C {madvlsi/vdd.sym} 240 -160 0 0 {name=l26 lab=VDD}
C {madvlsi/vsource.sym} 340 -140 0 0 {name=VCLK
value="pulse(0 1.8 5u 1n 1n 10u 20u)"}
C {madvlsi/gnd.sym} 340 -110 0 0 {name=l22 lab=GND}
C {devices/lab_pin.sym} 340 -170 0 0 {name=l25 sig_type=std_logic lab=CLK}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 280 -470 0 0 {name=X1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 430 -470 0 0 {name=X2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 560 -470 0 0 {name=X3
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 990 -470 0 0 {name=X6}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 1120 -470 0 0 {name=X7}
C {madvlsi/vdd.sym} 360 -530 0 0 {name=l18 lab=VDD}
C {madvlsi/vdd.sym} 510 -530 0 0 {name=l19 lab=VDD}
C {madvlsi/vdd.sym} 640 -530 0 0 {name=l20 lab=VDD}
C {madvlsi/vdd.sym} 790 -530 0 0 {name=l21 lab=VDD}
C {madvlsi/vdd.sym} 920 -530 0 0 {name=l24 lab=VDD}
C {madvlsi/vdd.sym} 1070 -530 0 0 {name=l27 lab=VDD}
C {madvlsi/vdd.sym} 1200 -530 0 0 {name=l28 lab=VDD}
C {madvlsi/gnd.sym} 360 -410 0 0 {name=l30 lab=GND}
C {madvlsi/gnd.sym} 510 -410 0 0 {name=l31 lab=GND}
C {madvlsi/gnd.sym} 640 -410 0 0 {name=l32 lab=GND}
C {madvlsi/gnd.sym} 790 -410 0 0 {name=l33 lab=GND}
C {madvlsi/gnd.sym} 920 -410 0 0 {name=l34 lab=GND}
C {madvlsi/gnd.sym} 1070 -410 0 0 {name=l35 lab=GND}
C {madvlsi/gnd.sym} 1200 -410 0 0 {name=l36 lab=GND}
C {devices/lab_pin.sym} 450 -560 1 0 {name=l40 sig_type=std_logic lab=Q0}
C {devices/lab_pin.sym} 600 -560 1 0 {name=l41 sig_type=std_logic lab=Q1}
C {devices/lab_pin.sym} 730 -560 1 0 {name=l42 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 880 -560 1 0 {name=l43 sig_type=std_logic lab=Q3}
C {devices/lab_pin.sym} 1010 -560 1 0 {name=l44 sig_type=std_logic lab=Q4}
C {devices/lab_pin.sym} 1160 -560 1 0 {name=l45 sig_type=std_logic lab=Q5}
C {devices/lab_pin.sym} 1290 -560 1 0 {name=l46 sig_type=std_logic lab=Q6}
C {madvlsi/tt_models.sym} 870 -210 0 0 {
name=TT_MODELS
only_toplevel=false
value=".option wnflag=1
.param MC_SWITCH=0.0
.lib /media/qdeng/526448C32060CF5C/skywater/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/sky130.lib.spice tt"
}
C {devices/code_shown.sym} 580 -210 0 0 {name=SPICE only_toplevel=false value=".ic v(Q0)=0 v(Qn0)=1.8 v(X1.Qi)=1.8
.ic v(Q1)=0 v(Qn1)=1.8 v(X2.Qi)=1.8
.ic v(Q2)=0 v(Qn2)=1.8 v(X3.Qi)=1.8
.ic v(Q3)=0 v(Qn3)=1.8 v(X4.Qi)=1.8
.ic v(Q4)=0 v(Qn4)=1.8 v(X5.Qi)=1.8
.ic v(Q5)=0 v(Qn5)=1.8 v(X6.Qi)=1.8
.ic v(Q6)=0 v(Qn6)=1.8 v(X7.Qi)=1.8
.control
  save v(Q0b) v(CLK) v(Q1b) v(Q2b) v(Q3b) v(Q4b) v(Q5b) v(Q6b) 
  tran 5u 500u
  plot v(Q0b) v(CLK) v(Q1b)
  plot v(Q1b) v(CLK) v(Q2b) 
  plot v(Q2b) v(CLK) v(Q3b) 
  plot v(Q3b) v(CLK) v(Q4b) 
  plot v(Q4b) v(CLK) v(Q5b)
  plot v(Q5b) v(CLK) v(Q6b)
  plot v(Q0s) v(Q1s) v(Q2s) v(Q3s)
.endc"}
C {devices/lab_pin.sym} 450 -450 1 0 {name=l47 sig_type=std_logic lab=Qn0}
C {devices/lab_pin.sym} 600 -450 1 0 {name=l48 sig_type=std_logic lab=Qn1}
C {devices/lab_pin.sym} 730 -450 1 0 {name=l49 sig_type=std_logic lab=Qn2}
C {devices/lab_pin.sym} 880 -450 1 0 {name=l50 sig_type=std_logic lab=Qn3}
C {devices/lab_pin.sym} 1010 -450 1 0 {name=l51 sig_type=std_logic lab=Qn4}
C {devices/lab_pin.sym} 1160 -450 1 0 {name=l52 sig_type=std_logic lab=Qn5}
C {devices/lab_pin.sym} 1290 -450 1 0 {name=l53 sig_type=std_logic lab=Qn6}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 450 -600 3 0 {name=X8 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 600 -600 3 0 {name=X9 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 730 -600 3 0 {name=X10 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 880 -600 3 0 {name=X11 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 1010 -600 3 0 {name=X12 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 1160 -600 3 0 {name=X13 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 1290 -600 3 0 {name=X14 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {devices/lab_pin.sym} 450 -660 1 0 {name=l1 sig_type=std_logic lab=Q0b}
C {devices/lab_pin.sym} 600 -660 1 0 {name=l2 sig_type=std_logic lab=Q1b}
C {devices/lab_pin.sym} 730 -660 1 0 {name=l3 sig_type=std_logic lab=Q2b}
C {devices/lab_pin.sym} 880 -660 1 0 {name=l4 sig_type=std_logic lab=Q3b}
C {devices/lab_pin.sym} 1010 -660 1 0 {name=l5 sig_type=std_logic lab=Q4b}
C {devices/lab_pin.sym} 1160 -660 1 0 {name=l6 sig_type=std_logic lab=Q5b}
C {devices/lab_pin.sym} 1290 -660 1 0 {name=l7 sig_type=std_logic lab=Q6b}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 450 -350 1 0 {name=X15 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 600 -350 1 0 {name=X16 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 730 -350 1 0 {name=X17 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 1010 -350 1 0 {name=X18 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 1160 -350 1 0 {name=X19 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 880 -350 1 0 {name=X20 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 840 -470 0 0 {name=X5}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/CSRL_D_FF.sym} 710 -470 0 0 {name=X4}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 520 -560 2 0 {name=X21 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 390 -560 2 0 {name=X22 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 800 -560 2 0 {name=X23 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 670 -560 2 0 {name=X24 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 1080 -560 2 0 {name=X25 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 950 -560 2 0 {name=X26 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/buffer.sym} 1230 -560 2 0 {name=X27 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {sky130_stdcells/dfxbp_1.sym} 420 190 0 0 {name=x1 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfxbp_1.sym} 630 190 0 0 {name=x2 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 510 140 1 0 {name=l8 sig_type=std_logic lab=Q0s}
C {devices/lab_pin.sym} 720 140 1 0 {name=l9 sig_type=std_logic lab=Q1s}
C {sky130_stdcells/dfxbp_1.sym} 840 190 0 0 {name=x3 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfxbp_1.sym} 1050 190 0 0 {name=x4 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 930 140 1 0 {name=l11 sig_type=std_logic lab=Q2s}
C {devices/lab_pin.sym} 1140 140 1 0 {name=l12 sig_type=std_logic lab=Q3b}
C {devices/lab_pin.sym} 330 180 0 0 {name=l13 sig_type=std_logic lab=CLK}
