v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 610 -70 670 -70 { lab=#net1}
N 410 10 410 40 { lab=Vnn}
N -60 -40 -60 -10 { lab=Vben}
N -60 -110 -60 -40 { lab=Vben}
N -220 -110 -220 -10 { lab=Vbep}
N -300 -140 -250 -140 { lab=#net2}
N -250 -140 -90 -140 { lab=#net2}
N -900 50 -900 80 { lab=GND}
N -940 50 -940 80 { lab=GND}
N -940 80 -900 80 { lab=GND}
N -900 80 -900 110 { lab=GND}
N -740 50 -740 80 { lab=GND}
N -740 80 -740 110 { lab=GND}
N -780 110 -740 110 { lab=GND}
N -740 110 -740 120 { lab=GND}
N -740 -110 -740 20 { lab=#net3}
N -740 -110 -480 -110 { lab=#net3}
N -900 -170 -480 -170 { lab=#net4}
N -900 -170 -900 -40 { lab=#net4}
N -500 -310 -500 -250 { lab=#net2}
N -500 -310 -300 -310 { lab=#net2}
N -300 -310 -300 -140 { lab=#net2}
N -870 -250 -710 -250 { lab=#net2}
N -710 -250 -500 -250 { lab=#net2}
N -740 -220 -740 -110 { lab=#net3}
N -900 -220 -900 -170 { lab=#net4}
N -180 20 -100 20 { lab=GND}
N -60 50 -60 110 { lab=GND}
N -220 50 -220 110 { lab=GND}
N -140 20 -140 80 { lab=GND}
N -140 80 -140 110 { lab=GND}
N 410 100 410 240 { lab=Vnn}
N 410 240 490 240 { lab=Vnn}
N 410 340 500 340 { lab=Vnn}
N 410 240 410 340 { lab=Vnn}
N 660 70 660 240 { lab=#net1}
N 550 240 660 240 { lab=#net1}
N 560 340 660 340 { lab=#net1}
N 660 240 660 340 { lab=#net1}
N 290 100 290 170 { lab=#net5}
N 270 100 310 100 { lab=#net5}
N 170 100 210 100 { lab=Vn}
N 290 230 290 280 { lab=Vref}
N 370 100 410 100 { lab=Vnn}
N 410 40 410 100 { lab=Vnn}
N 660 -70 660 70 { lab=#net1}
N 410 -440 410 -270 { lab=Vpp}
N 410 -440 490 -440 { lab=Vpp}
N 410 -470 410 -440 { lab=Vpp}
N 310 -330 310 -270 { lab=#net6}
N 290 -270 330 -270 { lab=#net6}
N 190 -270 230 -270 { lab=Vp}
N 550 -440 610 -440 { lab=Vref}
N 410 -570 410 -530 { lab=Vref}
N 310 -430 310 -390 { lab=Vref}
N 410 -40 410 10 { lab=Vnn}
N 410 -270 410 -100 { lab=Vpp}
N 390 -270 410 -270 { lab=Vpp}
N 410 -60 410 -40 { lab=Vnn}
N 410 -100 410 -80 { lab=Vpp}
N 590 -70 610 -70 { lab=#net1}
N -480 -150 -380 -150 { lab=#net4}
N -480 -170 -480 -150 { lab=#net4}
N -480 -130 -480 -110 { lab=#net3}
N -480 -130 -380 -130 { lab=#net3}
N 410 -60 510 -60 { lab=Vnn}
N 410 -80 510 -80 { lab=Vpp}
N -180 340 -180 370 { lab=Vref}
N -180 370 -100 370 { lab=Vref}
N -100 330 -100 370 { lab=Vref}
N 670 -70 720 -70 { lab=#net1}
N 610 1010 670 1010 { lab=#net7}
N 410 1090 410 1120 { lab=#net8}
N 410 1180 410 1320 { lab=#net8}
N 410 1320 490 1320 { lab=#net8}
N 410 1420 500 1420 { lab=#net8}
N 410 1320 410 1420 { lab=#net8}
N 660 1150 660 1320 { lab=#net7}
N 550 1320 660 1320 { lab=#net7}
N 560 1420 660 1420 { lab=#net7}
N 660 1320 660 1420 { lab=#net7}
N 290 1180 290 1250 { lab=#net9}
N 270 1180 310 1180 { lab=#net9}
N 170 1180 210 1180 { lab=Vn}
N 290 1310 290 1360 { lab=Vref}
N 370 1180 410 1180 { lab=#net8}
N 410 1120 410 1180 { lab=#net8}
N 660 1010 660 1150 { lab=#net7}
N 410 640 410 810 { lab=#net10}
N 410 640 490 640 { lab=#net10}
N 410 610 410 640 { lab=#net10}
N 310 750 310 810 { lab=#net11}
N 290 810 330 810 { lab=#net11}
N 190 810 230 810 { lab=Vp}
N 550 640 610 640 { lab=Vref}
N 410 510 410 550 { lab=Vref}
N 310 650 310 690 { lab=Vref}
N 410 1040 410 1090 { lab=#net8}
N 410 810 410 980 { lab=#net10}
N 390 810 410 810 { lab=#net10}
N 410 1020 410 1040 { lab=#net8}
N 410 980 410 1000 { lab=#net10}
N 590 1010 610 1010 { lab=#net7}
N 410 1020 510 1020 { lab=#net8}
N 410 1000 510 1000 { lab=#net10}
N 720 -70 810 -70 { lab=#net1}
N 810 -70 810 160 { lab=#net1}
N 810 220 810 810 { lab=Vout}
N 720 1010 810 1010 { lab=#net7}
N 810 970 810 1010 { lab=#net7}
N 810 810 810 930 { lab=Vout}
N 1560 1010 1620 1010 { lab=#net12}
N 1360 1090 1360 1120 { lab=#net13}
N 1360 1180 1360 1320 { lab=#net13}
N 1360 1320 1440 1320 { lab=#net13}
N 1360 1420 1450 1420 { lab=#net13}
N 1360 1320 1360 1420 { lab=#net13}
N 1610 1150 1610 1320 { lab=#net12}
N 1500 1320 1610 1320 { lab=#net12}
N 1510 1420 1610 1420 { lab=#net12}
N 1610 1320 1610 1420 { lab=#net12}
N 1240 1180 1240 1250 { lab=#net14}
N 1220 1180 1260 1180 { lab=#net14}
N 1120 1180 1160 1180 { lab=Vn}
N 1240 1310 1240 1360 { lab=Vouts}
N 1320 1180 1360 1180 { lab=#net13}
N 1360 1120 1360 1180 { lab=#net13}
N 1610 1010 1610 1150 { lab=#net12}
N 1360 640 1360 810 { lab=#net15}
N 1360 640 1440 640 { lab=#net15}
N 1360 610 1360 640 { lab=#net15}
N 1260 750 1260 810 { lab=#net16}
N 1240 810 1280 810 { lab=#net16}
N 1140 810 1180 810 { lab=Vp}
N 1500 640 1560 640 { lab=Vouts}
N 1360 510 1360 550 { lab=Vouts}
N 1260 650 1260 690 { lab=Vouts}
N 1360 1040 1360 1090 { lab=#net13}
N 1360 810 1360 980 { lab=#net15}
N 1340 810 1360 810 { lab=#net15}
N 1360 1020 1360 1040 { lab=#net13}
N 1360 980 1360 1000 { lab=#net15}
N 1540 1010 1560 1010 { lab=#net12}
N 1360 1020 1460 1020 { lab=#net13}
N 1360 1000 1460 1000 { lab=#net15}
N 670 1010 720 1010 { lab=#net7}
N 1560 -70 1620 -70 { lab=#net17}
N 1360 10 1360 40 { lab=#net18}
N 1360 100 1360 240 { lab=#net18}
N 1360 240 1440 240 { lab=#net18}
N 1360 340 1450 340 { lab=#net18}
N 1360 240 1360 340 { lab=#net18}
N 1610 70 1610 240 { lab=#net17}
N 1500 240 1610 240 { lab=#net17}
N 1510 340 1610 340 { lab=#net17}
N 1610 240 1610 340 { lab=#net17}
N 1240 100 1240 170 { lab=#net19}
N 1220 100 1260 100 { lab=#net19}
N 1120 100 1160 100 { lab=Vn}
N 1240 230 1240 280 { lab=Vouts}
N 1320 100 1360 100 { lab=#net18}
N 1360 40 1360 100 { lab=#net18}
N 1610 -70 1610 70 { lab=#net17}
N 1360 -440 1360 -270 { lab=#net20}
N 1360 -440 1440 -440 { lab=#net20}
N 1360 -470 1360 -440 { lab=#net20}
N 1260 -330 1260 -270 { lab=#net21}
N 1240 -270 1280 -270 { lab=#net21}
N 1140 -270 1180 -270 { lab=Vp}
N 1500 -440 1560 -440 { lab=Vouts}
N 1360 -570 1360 -530 { lab=Vouts}
N 1260 -430 1260 -390 { lab=Vouts}
N 1360 -40 1360 10 { lab=#net18}
N 1360 -270 1360 -100 { lab=#net20}
N 1340 -270 1360 -270 { lab=#net20}
N 1360 -60 1360 -40 { lab=#net18}
N 1360 -100 1360 -80 { lab=#net20}
N 1540 -70 1560 -70 { lab=#net17}
N 1360 -60 1460 -60 { lab=#net18}
N 1360 -80 1460 -80 { lab=#net20}
N 1620 -70 1670 -70 { lab=#net17}
N 1670 -70 1760 -70 { lab=#net17}
N 1760 -70 1760 160 { lab=#net17}
N 1760 220 1760 810 { lab=Vptat}
N 1760 970 1760 1010 { lab=#net12}
N 1760 810 1760 930 { lab=Vptat}
N 1620 1010 1760 1010 { lab=#net12}
N -300 330 -260 330 { lab=Vn}
N 110 340 150 340 { lab=Vp}
N -380 340 -380 370 { lab=Vn}
N -380 370 -300 370 { lab=Vn}
N -300 330 -300 370 { lab=Vn}
N 30 350 30 380 { lab=Vp}
N 30 380 110 380 { lab=Vp}
N 110 340 110 380 { lab=Vp}
N 1050 780 1050 830 { lab=Vouts}
N 1040 830 1050 830 { lab=Vouts}
N 970 830 980 830 { lab=#net22}
N 970 790 970 830 { lab=#net22}
N 950 790 970 790 { lab=#net22}
N 810 770 890 770 { lab=Vout}
N 950 770 970 770 { lab=#net23}
N 970 750 970 770 { lab=#net23}
N 890 790 890 870 { lab=GND}
N 950 870 970 870 { lab=#net22}
N 970 830 970 870 { lab=#net22}
N 1760 310 2430 310 { lab=Vptat}
N 2820 320 2840 320 { lab=Vout}
N 2780 320 2820 320 { lab=Vout}
N 2640 330 2700 330 { lab=Vneg}
N 2770 410 2800 410 { lab=Vout}
N 2800 320 2800 410 { lab=Vout}
N 2690 410 2710 410 { lab=Vneg}
N 2690 330 2690 410 { lab=Vneg}
N 2510 330 2580 330 { lab=#net24}
N 3070 320 3100 320 { lab=#net25}
N 2920 310 3000 310 { lab=Vflag}
N 3380 180 3380 200 { lab=#net25}
N 3100 320 3380 320 { lab=#net25}
N 3410 90 3440 90 { lab=#net26}
N 3530 140 3590 140 { lab=Qn0}
N 3590 0 3590 140 { lab=Qn0}
N 3290 0 3590 0 { lab=Qn0}
N 3290 0 3290 90 { lab=Qn0}
N 3290 90 3320 90 { lab=Qn0}
N 3500 180 3500 200 { lab=#net27}
N 3500 300 3500 320 { lab=#net25}
N 3380 320 3500 320 { lab=#net25}
N 3780 90 3810 90 { lab=#net28}
N 3900 140 3960 140 { lab=Qn1}
N 3960 0 3960 140 { lab=Qn1}
N 3660 0 3960 0 { lab=Qn1}
N 3660 0 3660 90 { lab=Qn1}
N 3660 90 3690 90 { lab=Qn1}
N 4150 90 4180 90 { lab=#net29}
N 4270 140 4330 140 { lab=Qn2}
N 4330 0 4330 140 { lab=Qn2}
N 4030 0 4330 0 { lab=Qn2}
N 4030 0 4030 90 { lab=Qn2}
N 4030 90 4060 90 { lab=Qn2}
N 4520 90 4550 90 { lab=#net30}
N 4640 140 4700 140 { lab=Qn3}
N 4700 0 4700 140 { lab=Qn3}
N 4400 0 4700 0 { lab=Qn3}
N 4400 0 4400 90 { lab=Qn3}
N 4400 90 4430 90 { lab=Qn3}
N 3870 180 3870 320 { lab=Q0}
N 3590 320 3870 320 { lab=Q0}
N 3750 280 3750 320 { lab=Q0}
N 4240 180 4240 320 { lab=Q1}
N 3960 320 4240 320 { lab=Q1}
N 4120 280 4120 320 { lab=Q1}
N 4610 180 4610 320 { lab=Q2}
N 4330 320 4610 320 { lab=Q2}
N 4490 280 4490 320 { lab=Q2}
N 3430 -20 3430 90 { lab=#net26}
N 3790 -20 3790 90 { lab=#net28}
N 4150 -20 4150 90 { lab=#net29}
N 4520 -20 4520 90 { lab=#net30}
N 3380 300 3380 320 { lab=#net25}
N 3380 200 3380 300 { lab=#net25}
N 4890 90 4920 90 { lab=#net31}
N 5010 140 5070 140 { lab=Qn4}
N 5070 0 5070 140 { lab=Qn4}
N 4770 0 5070 0 { lab=Qn4}
N 4770 0 4770 90 { lab=Qn4}
N 4770 90 4800 90 { lab=Qn4}
N 4980 180 4980 320 { lab=Q3}
N 4700 320 4980 320 { lab=Q3}
N 4860 280 4860 320 { lab=Q3}
N 4890 -20 4890 90 { lab=#net31}
N 5260 90 5290 90 { lab=#net32}
N 5380 140 5440 140 { lab=Qn5}
N 5440 0 5440 140 { lab=Qn5}
N 5140 0 5440 0 { lab=Qn5}
N 5140 0 5140 90 { lab=Qn5}
N 5140 90 5170 90 { lab=Qn5}
N 5630 90 5660 90 { lab=#net33}
N 5750 140 5810 140 { lab=Qn6}
N 5810 0 5810 140 { lab=Qn6}
N 5510 0 5810 0 { lab=Qn6}
N 5510 0 5510 90 { lab=Qn6}
N 5510 90 5540 90 { lab=Qn6}
N 6000 90 6030 90 { lab=#net34}
N 6120 140 6180 140 { lab=Qn7}
N 6180 0 6180 140 { lab=Qn7}
N 5880 0 6180 0 { lab=Qn7}
N 5880 0 5880 90 { lab=Qn7}
N 5880 90 5910 90 { lab=Qn7}
N 5350 180 5350 320 { lab=Q4}
N 5070 320 5350 320 { lab=Q4}
N 5230 280 5230 320 { lab=Q4}
N 5720 180 5720 320 { lab=Q5}
N 5440 320 5720 320 { lab=Q5}
N 5600 280 5600 320 { lab=Q5}
N 6090 180 6090 320 { lab=Q6}
N 5810 320 6090 320 { lab=Q6}
N 5970 280 5970 320 { lab=Q6}
N 5270 -20 5270 90 { lab=#net32}
N 5630 -20 5630 90 { lab=#net33}
N 6000 -20 6000 90 { lab=#net34}
N 6360 90 6390 90 { lab=#net35}
N 6480 140 6540 140 { lab=Qn8}
N 6540 0 6540 140 { lab=Qn8}
N 6240 0 6540 0 { lab=Qn8}
N 6240 0 6240 90 { lab=Qn8}
N 6240 90 6270 90 { lab=Qn8}
N 6450 180 6450 320 { lab=Q7}
N 6170 320 6450 320 { lab=Q7}
N 6330 280 6330 320 { lab=Q7}
N 6360 -20 6360 90 { lab=#net35}
N 2770 530 2800 530 { lab=Vout}
N 2800 410 2800 530 { lab=Vout}
N 2690 410 2690 530 { lab=Vneg}
N 2690 530 2710 530 { lab=Vneg}
N 2800 530 2830 530 { lab=Vout}
C {madvlsi/vsource.sym} -650 430 0 0 {name=Vdd
value=1.8}
C {madvlsi/vdd.sym} -650 400 0 0 {name=l3 lab=VDD}
C {madvlsi/gnd.sym} -650 460 0 0 {name=l4 lab=GND}
C {devices/code_shown.sym} -2110 320 0 0 {name=SPICE only_toplevel=false value=".param Iref=1u n=5 
.param Wp=3 Lp=0.6 WW=3 LL=0.6
.param mult=8
.control
  save all
*v(vbep) v(vben) v(vout) v(vphi1) v(vphi2) v(vref) v(vouts) v(vptat)
  let startTemp = 20
  let currTemp = startTemp
  let endTemp = 20
  let dt = 5
  set appendwrite = FALSE
  set wr_vecnames
  while currTemp <= endTemp
    destroy all
    option temp=$&currTemp
    tran 10u 50u
    wrdata /home/madvlsi/Documents/MADVLSI-Final_Project/schematic/data/SCbandgap\{$&currTemp\}ptat.csv v(vbep) v(vben) v(vout) v(vphi1) v(vphi2) v(vref) v(vouts) v(vptat) currTemp
    let currTemp = currTemp + dt
    reset
  end
*plot v(Vout) 8.0*(v(Vbep)-v(Vben))+v(Vben)
*plot v(Vout) v(Vouts)
.endc
.OPTIONS ITL1=300  ITL2=100"}
C {sky130_fd_pr/pnp_05v5.sym} -200 20 0 1 {name=Q2
model=pnp_05v5_W0p68L0p68
spiceprefix=X
}
C {madvlsi/vdd.sym} -220 -170 0 0 {name=l2 lab=VDD}
C {madvlsi/vdd.sym} -60 -170 0 0 {name=l5 lab=VDD}
C {devices/lab_pin.sym} -220 -60 0 0 {name=l10 sig_type=std_logic lab=Vbep}
C {devices/lab_pin.sym} -60 -60 0 0 {name=l11 sig_type=std_logic lab=Vben}
C {madvlsi/pmos3.sym} -220 -140 0 0 {name=M1
L=Lp
W=Wp
body=VDD
nf=1
mult=mult
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -60 -140 0 0 {name=M2
L=Lp
W=Wp
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} -80 20 0 0 {name=Q4[mult:0]
model=pnp_05v5_W0p68L0p68
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} -920 50 0 0 {name=Q1
model=pnp_05v5_W0p68L0p68
spiceprefix=X
}
C {madvlsi/gnd.sym} -900 110 0 0 {name=l19 lab=GND}
C {sky130_fd_pr/pnp_05v5.sym} -760 50 0 0 {name=Q3
model=pnp_05v5_W0p68L0p68
spiceprefix=X
}
C {madvlsi/gnd.sym} -740 120 0 0 {name=l20 lab=GND}
C {madvlsi/resistor.sym} -900 -10 0 0 {name=R1
value=160k
m=1}
C {madvlsi/resistor.sym} -780 80 0 0 {name=R2
value=160k
m=mult}
C {madvlsi/pmos3.sym} -900 -250 0 1 {name=M3
L=Lp
W=Wp
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -740 -250 0 1 {name=M4
L=Lp
W=Wp
body=VDD
nf=1
mult=mult
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} -740 -280 0 0 {name=l21 lab=VDD}
C {madvlsi/vdd.sym} -900 -280 0 0 {name=l22 lab=VDD}
C {madvlsi/gnd.sym} -220 20 1 1 {name=l25 lab=GND}
C {madvlsi/gnd.sym} -60 20 3 1 {name=l26 lab=GND}
C {madvlsi/gnd.sym} -60 110 0 1 {name=l27 lab=GND}
C {madvlsi/gnd.sym} -220 110 0 1 {name=l28 lab=GND}
C {madvlsi/gnd.sym} -140 110 0 1 {name=l29 lab=GND}
C {devices/lab_pin.sym} 410 -140 0 0 {name=l6 sig_type=std_logic lab=Vpp}
C {devices/lab_pin.sym} 410 10 0 0 {name=l13 sig_type=std_logic lab=Vnn}
C {madvlsi/capacitor.sym} 340 100 1 0 {name=C5
value=800f
m=1}
C {madvlsi/capacitor.sym} 520 240 1 0 {name=C6
value=100f
m=1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 240 100 0 0 {name=X10}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 290 200 3 0 {name=X11}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 530 340 0 0 {name=X12}
C {devices/lab_pin.sym} 290 280 3 0 {name=l1 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 520 360 3 0 {name=l31 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 540 360 3 0 {name=l32 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 230 120 3 0 {name=l33 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 250 120 3 0 {name=l50 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 310 210 2 0 {name=l51 sig_type=std_logic lab=Vphi2}
C {madvlsi/capacitor.sym} 360 -270 1 0 {name=C2
value=800f
m=1}
C {madvlsi/capacitor.sym} 520 -440 1 0 {name=C4
value=100f
m=1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 260 -270 2 0 {name=X5}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 310 -360 3 0 {name=X7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 410 -500 1 0 {name=X9}
C {devices/lab_pin.sym} 410 -570 1 0 {name=l36 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 310 -430 1 0 {name=l38 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 270 -290 1 0 {name=l44 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 250 -290 1 0 {name=l49 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 330 -350 2 0 {name=l52 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 330 -370 2 0 {name=l53 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 610 -440 2 0 {name=l54 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} -100 330 2 0 {name=l56 sig_type=std_logic lab=Vref}
C {madvlsi/vsource.sym} -470 900 0 0 {name=Vphi1
value="pulse(0, 1.8, 0, 1n, 1n, 6u, 12u)"}
C {madvlsi/gnd.sym} -470 930 0 0 {name=l30 lab=GND}
C {devices/lab_pin.sym} -160 830 2 0 {name=l58 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} -160 850 2 0 {name=l62 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} -160 930 2 0 {name=l68 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 310 190 2 0 {name=l34 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 190 -270 1 0 {name=l35 sig_type=std_logic lab=Vp}
C {devices/lab_pin.sym} 170 100 1 0 {name=l37 sig_type=std_logic lab=Vn}
C {devices/lab_pin.sym} 390 -510 0 0 {name=l39 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 390 -490 0 0 {name=l40 sig_type=std_logic lab=Vnphi1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage.sym} -340 -140 0 0 {name=X2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage.sym} 550 -70 0 0 {name=X1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage.sym} -140 330 0 0 {name=X16}
C {devices/lab_pin.sym} -180 320 0 0 {name=l15 sig_type=std_logic lab=Vben}
C {madvlsi/tt_models.sym} 770 -830 0 0 {
name=TT_MODELS
only_toplevel=false
value=".option wnflag=1
.param MC_SWITCH=0.0
.lib /media/qdeng/526448C32060CF5C/skywater/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/sky130.lib.spice tt"
}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/clk_gen.sym} -220 880 0 0 {name=X6 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {devices/lab_pin.sym} -160 910 2 0 {name=l7 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} -470 870 1 0 {name=l16 sig_type=std_logic lab=VCLK}
C {devices/lab_pin.sym} -280 930 0 0 {name=l17 sig_type=std_logic lab=VCLK}
C {devices/lab_pin.sym} 810 770 2 0 {name=l18 sig_type=std_logic lab=Vout}
C {madvlsi/capacitor.sym} 340 1180 1 0 {name=C1
value=800f
m=1}
C {madvlsi/capacitor.sym} 520 1320 1 0 {name=C3
value=100f
m=1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 240 1180 0 0 {name=X4}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 290 1280 3 0 {name=X8}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 530 1420 0 0 {name=X13}
C {devices/lab_pin.sym} 290 1360 3 0 {name=l41 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 520 1440 3 0 {name=l42 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 540 1440 3 0 {name=l43 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 230 1200 3 0 {name=l45 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 250 1200 3 0 {name=l46 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 310 1290 2 0 {name=l47 sig_type=std_logic lab=Vphi1}
C {madvlsi/capacitor.sym} 360 810 1 0 {name=C7
value=800f
m=1}
C {madvlsi/capacitor.sym} 520 640 1 0 {name=C8
value=100f
m=1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 260 810 2 0 {name=X14}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 310 720 3 0 {name=X17}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 410 580 1 0 {name=X18}
C {devices/lab_pin.sym} 410 510 1 0 {name=l48 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 310 650 1 0 {name=l55 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 270 790 1 0 {name=l57 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 250 790 1 0 {name=l59 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 330 730 2 0 {name=l60 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 330 710 2 0 {name=l61 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 610 640 2 0 {name=l63 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 310 1270 2 0 {name=l64 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 190 810 1 0 {name=l65 sig_type=std_logic lab=Vp}
C {devices/lab_pin.sym} 170 1180 1 0 {name=l66 sig_type=std_logic lab=Vn}
C {devices/lab_pin.sym} 390 570 0 0 {name=l67 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 390 590 0 0 {name=l69 sig_type=std_logic lab=Vnphi2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage.sym} 550 1010 0 0 {name=X19}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 810 190 3 0 {name=X20}
C {devices/lab_pin.sym} 830 200 2 0 {name=l70 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 830 180 2 0 {name=l71 sig_type=std_logic lab=Vnphi2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 810 950 3 0 {name=X21}
C {devices/lab_pin.sym} 830 960 2 0 {name=l72 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 830 940 2 0 {name=l73 sig_type=std_logic lab=Vnphi1}
C {madvlsi/capacitor.sym} 780 480 1 0 {name=C9
value=800f
m=1}
C {madvlsi/gnd.sym} 750 480 1 1 {name=l12 lab=GND}
C {madvlsi/capacitor.sym} 780 550 1 0 {name=C10
value=800f
m=1}
C {madvlsi/gnd.sym} 750 550 1 1 {name=l23 lab=GND}
C {madvlsi/capacitor.sym} 1290 1180 1 0 {name=C11
value=300f
m=1}
C {madvlsi/capacitor.sym} 1470 1320 1 0 {name=C12
value=100f
m=1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1190 1180 0 0 {name=X22}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1240 1280 3 0 {name=X23}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1480 1420 0 0 {name=X24}
C {devices/lab_pin.sym} 1470 1440 3 0 {name=l74 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 1490 1440 3 0 {name=l75 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 1180 1200 3 0 {name=l76 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 1200 1200 3 0 {name=l77 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 1260 1290 2 0 {name=l78 sig_type=std_logic lab=Vphi1}
C {madvlsi/capacitor.sym} 1310 810 1 0 {name=C13
value=300f
m=1}
C {madvlsi/capacitor.sym} 1470 640 1 0 {name=C14
value=100f
m=1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1210 810 2 0 {name=X25}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1260 720 3 0 {name=X26}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1360 580 1 0 {name=X27}
C {devices/lab_pin.sym} 1220 790 1 0 {name=l81 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 1200 790 1 0 {name=l82 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 1280 730 2 0 {name=l83 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 1280 710 2 0 {name=l84 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 1260 1270 2 0 {name=l86 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 1140 810 1 0 {name=l87 sig_type=std_logic lab=Vp}
C {devices/lab_pin.sym} 1120 1180 1 0 {name=l88 sig_type=std_logic lab=Vn}
C {devices/lab_pin.sym} 1340 570 0 0 {name=l89 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 1340 590 0 0 {name=l90 sig_type=std_logic lab=Vnphi2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage.sym} 1500 1010 0 0 {name=X28}
C {devices/lab_pin.sym} 1240 1360 3 0 {name=l24 sig_type=std_logic lab=Vouts}
C {devices/lab_pin.sym} 1560 640 2 0 {name=l79 sig_type=std_logic lab=Vouts}
C {devices/lab_pin.sym} 1360 510 1 0 {name=l80 sig_type=std_logic lab=Vouts}
C {devices/lab_pin.sym} 1260 650 1 0 {name=l85 sig_type=std_logic lab=Vouts}
C {madvlsi/capacitor.sym} 1290 100 1 0 {name=C15
value=300f
m=1}
C {madvlsi/capacitor.sym} 1470 240 1 0 {name=C16
value=100f
m=1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1190 100 0 0 {name=X29}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1240 200 3 0 {name=X30}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1480 340 0 0 {name=X31}
C {devices/lab_pin.sym} 1470 360 3 0 {name=l94 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 1490 360 3 0 {name=l95 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 1180 120 3 0 {name=l96 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 1200 120 3 0 {name=l97 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 1260 210 2 0 {name=l98 sig_type=std_logic lab=Vphi2}
C {madvlsi/capacitor.sym} 1310 -270 1 0 {name=C17
value=300f
m=1}
C {madvlsi/capacitor.sym} 1470 -440 1 0 {name=C18
value=100f
m=1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1210 -270 2 0 {name=X32}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1260 -360 3 0 {name=X33}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1360 -500 1 0 {name=X34}
C {devices/lab_pin.sym} 1220 -290 1 0 {name=l101 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 1200 -290 1 0 {name=l102 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 1280 -350 2 0 {name=l103 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 1280 -370 2 0 {name=l104 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 1260 190 2 0 {name=l106 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 1140 -270 1 0 {name=l107 sig_type=std_logic lab=Vp}
C {devices/lab_pin.sym} 1120 100 1 0 {name=l108 sig_type=std_logic lab=Vn}
C {devices/lab_pin.sym} 1340 -510 0 0 {name=l109 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 1340 -490 0 0 {name=l110 sig_type=std_logic lab=Vnphi1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage.sym} 1500 -70 0 0 {name=X35}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1760 190 3 0 {name=X38}
C {devices/lab_pin.sym} 1780 200 2 0 {name=l114 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 1780 180 2 0 {name=l115 sig_type=std_logic lab=Vnphi2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1760 950 3 0 {name=X39}
C {devices/lab_pin.sym} 1780 960 2 0 {name=l116 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 1780 940 2 0 {name=l117 sig_type=std_logic lab=Vnphi1}
C {madvlsi/capacitor.sym} 1730 500 1 0 {name=C19
value=800f
m=1}
C {madvlsi/gnd.sym} 1700 500 1 1 {name=l118 lab=GND}
C {madvlsi/capacitor.sym} 1730 570 1 0 {name=C20
value=800f
m=1}
C {madvlsi/gnd.sym} 1700 570 1 1 {name=l119 lab=GND}
C {devices/lab_pin.sym} 1760 540 2 0 {name=l120 sig_type=std_logic lab=Vptat}
C {devices/lab_pin.sym} 1260 -430 1 0 {name=l93 sig_type=std_logic lab=Vouts}
C {devices/lab_pin.sym} 1360 -570 1 0 {name=l99 sig_type=std_logic lab=Vouts}
C {devices/lab_pin.sym} 1560 -440 2 0 {name=l100 sig_type=std_logic lab=Vouts}
C {devices/lab_pin.sym} 1240 280 3 0 {name=l105 sig_type=std_logic lab=Vouts}
C {devices/lab_pin.sym} 110 340 1 0 {name=l91 sig_type=std_logic lab=Vp}
C {devices/lab_pin.sym} -300 330 1 0 {name=l92 sig_type=std_logic lab=Vn}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage.sym} -340 330 0 0 {name=X36}
C {devices/lab_pin.sym} -380 320 0 0 {name=l111 sig_type=std_logic lab=Vbep}
C {devices/lab_pin.sym} 30 330 0 0 {name=l112 sig_type=std_logic lab=Vben}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage.sym} 70 340 0 0 {name=X37}
C {devices/lab_pin.sym} 30 330 0 0 {name=l113 sig_type=std_logic lab=Vben}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage.sym} 1010 780 0 0 {name=X3}
C {madvlsi/resistor.sym} 1010 830 1 0 {name=R3
value=120k
m=1}
C {madvlsi/resistor.sym} 920 790 1 0 {name=R4
value=160k
m=1}
C {madvlsi/capacitor.sym} 920 870 3 0 {name=C21
value=100f
m=1}
C {devices/lab_pin.sym} 1050 780 2 0 {name=l9 sig_type=std_logic lab=Vouts}
C {madvlsi/resistor.sym} 920 770 3 0 {name=R5
value=160k
m=1}
C {madvlsi/resistor.sym} 970 720 2 0 {name=R6
value=120k
m=1}
C {madvlsi/gnd.sym} 970 690 2 1 {name=l8 lab=GND}
C {madvlsi/gnd.sym} 890 790 1 1 {name=l14 lab=GND}
C {madvlsi/vsource.sym} -980 900 0 0 {name=Vdd1
value=1.8}
C {madvlsi/gnd.sym} -980 930 0 0 {name=l121 lab=GND}
C {madvlsi/vdd.sym} -980 870 0 0 {name=l122 lab=VDD}
C {devices/lab_pin.sym} 2800 320 1 0 {name=l125 sig_type=std_logic lab=Vout}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage.sym} 2740 320 0 0 {name=X15}
C {madvlsi/vsource.sym} -870 900 0 0 {name=Vref
value=0.9}
C {madvlsi/gnd.sym} -870 930 0 0 {name=l127 lab=GND}
C {devices/lab_pin.sym} -870 870 1 0 {name=l128 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 2700 310 0 0 {name=l129 sig_type=std_logic lab=Vref}
C {madvlsi/resistor.sym} 2610 330 1 0 {name=R7
value=1meg
m=1}
C {madvlsi/capacitor.sym} 2740 410 1 0 {name=C22
value=4n
m=1}
C {devices/lab_pin.sym} 2670 330 3 0 {name=l130 sig_type=std_logic lab=Vneg}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/transmission_gate.sym} 2470 330 0 0 {name=X40}
C {madvlsi/gnd.sym} 2430 350 1 0 {name=l131 lab=GND}
C {devices/lab_pin.sym} 2840 300 1 0 {name=l132 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 2950 310 1 0 {name=l133 sig_type=std_logic lab=Vflag}
C {devices/lab_pin.sym} 3000 330 0 0 {name=l134 sig_type=std_logic lab=CLK}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/and2.sym} 2970 320 0 0 {name=X41}
C {madvlsi/vdd.sym} 3030 290 0 0 {name=l135 lab=VDD}
C {madvlsi/gnd.sym} 3030 350 0 0 {name=l136 lab=GND}
C {madvlsi/vsource.sym} -680 900 0 0 {name=VCLK
value="pulse(0 1.8 0 1n 1n 6u 12u)"}
C {madvlsi/gnd.sym} -680 930 0 0 {name=l137 lab=GND}
C {devices/lab_pin.sym} -680 870 1 0 {name=l138 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 2470 370 3 0 {name=l139 sig_type=std_logic lab=Q8}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/comparator_amp.sym} 2880 310 0 0 {name=X42}
C {devices/lab_pin.sym} 3430 -120 1 0 {name=l140 sig_type=std_logic lab=Q0}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 3270 120 0 0 {name=X43}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 3390 120 0 0 {name=X44}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3500 260 3 0 {name=X45 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 3460 260 3 0 {name=l141 lab=VDD}
C {madvlsi/gnd.sym} 3540 260 3 0 {name=l142 lab=GND}
C {devices/lab_pin.sym} 3790 -120 1 0 {name=l143 sig_type=std_logic lab=Q1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 3640 120 0 0 {name=X46}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 3760 120 0 0 {name=X53}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3750 240 3 0 {name=X54 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 3710 240 3 0 {name=l144 lab=VDD}
C {madvlsi/gnd.sym} 3790 240 3 0 {name=l145 lab=GND}
C {devices/lab_pin.sym} 3590 140 2 0 {name=l146 sig_type=std_logic lab=Qn0}
C {devices/lab_pin.sym} 3960 140 2 0 {name=l147 sig_type=std_logic lab=Qn1}
C {devices/lab_pin.sym} 4150 -120 1 0 {name=l148 sig_type=std_logic lab=Q2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 4010 120 0 0 {name=X55}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 4130 120 0 0 {name=X56}
C {devices/lab_pin.sym} 4330 140 2 0 {name=l149 sig_type=std_logic lab=Qn2}
C {devices/lab_pin.sym} 4520 -120 1 0 {name=l150 sig_type=std_logic lab=Q3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 4380 120 0 0 {name=X57}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 4500 120 0 0 {name=X58}
C {devices/lab_pin.sym} 4700 140 2 0 {name=l151 sig_type=std_logic lab=Qn3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 4120 240 3 0 {name=X61 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 4080 240 3 0 {name=l152 lab=VDD}
C {madvlsi/gnd.sym} 4160 240 3 0 {name=l153 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 4490 240 3 0 {name=X62 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 4450 240 3 0 {name=l154 lab=VDD}
C {madvlsi/gnd.sym} 4530 240 3 0 {name=l155 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3430 -60 3 0 {name=X64 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 3390 -60 3 0 {name=l156 lab=VDD}
C {madvlsi/gnd.sym} 3470 -60 3 0 {name=l157 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 3790 -60 3 0 {name=X65 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 3750 -60 3 0 {name=l158 lab=VDD}
C {madvlsi/gnd.sym} 3830 -60 3 0 {name=l159 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 4150 -60 3 0 {name=X66 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 4110 -60 3 0 {name=l160 lab=VDD}
C {madvlsi/gnd.sym} 4190 -60 3 0 {name=l161 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 4520 -60 3 0 {name=X67 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 4480 -60 3 0 {name=l162 lab=VDD}
C {madvlsi/gnd.sym} 4560 -60 3 0 {name=l163 lab=GND}
C {devices/lab_pin.sym} 3590 320 0 0 {name=l164 sig_type=std_logic lab=Q0}
C {devices/lab_pin.sym} 3960 320 0 0 {name=l165 sig_type=std_logic lab=Q1}
C {devices/lab_pin.sym} 4330 320 0 0 {name=l166 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 4700 320 0 0 {name=l167 sig_type=std_logic lab=Q3}
C {madvlsi/vsource.sym} 2980 -100 0 0 {name=Vdd2
value="pwl(0 0 50u 0 51u 1.8)"}
C {madvlsi/gnd.sym} 2980 -70 0 0 {name=l168 lab=GND}
C {madvlsi/vsource.sym} 2800 -100 0 0 {name=Vdd3
value=1.8}
C {madvlsi/gnd.sym} 2800 -70 0 0 {name=l169 lab=GND}
C {devices/lab_pin.sym} 2980 -130 0 0 {name=l170 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 2800 -130 0 0 {name=l171 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 3320 120 0 0 {name=l172 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 3320 150 0 0 {name=l173 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 3440 150 0 0 {name=l174 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 3440 120 0 0 {name=l175 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 3690 120 0 0 {name=l176 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 3690 150 0 0 {name=l177 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 4060 120 0 0 {name=l178 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 4060 150 0 0 {name=l179 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 4430 120 0 0 {name=l180 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 4430 150 0 0 {name=l181 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 3810 150 0 0 {name=l182 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 3810 120 0 0 {name=l183 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 4180 150 0 0 {name=l184 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 4180 120 0 0 {name=l185 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 4550 150 0 0 {name=l186 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 4550 120 0 0 {name=l187 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 4890 -120 1 0 {name=l188 sig_type=std_logic lab=Q4}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 4750 120 0 0 {name=X47}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 4870 120 0 0 {name=X48}
C {devices/lab_pin.sym} 5070 140 2 0 {name=l189 sig_type=std_logic lab=Qn4}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 4860 240 3 0 {name=X49 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 4820 240 3 0 {name=l190 lab=VDD}
C {madvlsi/gnd.sym} 4900 240 3 0 {name=l191 lab=GND}
C {devices/lab_pin.sym} 4700 320 0 0 {name=l192 sig_type=std_logic lab=Q3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 4890 -60 3 0 {name=X50 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 4850 -60 3 0 {name=l193 lab=VDD}
C {madvlsi/gnd.sym} 4930 -60 3 0 {name=l194 lab=GND}
C {devices/lab_pin.sym} 4800 120 0 0 {name=l197 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 4800 150 0 0 {name=l198 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 4920 150 0 0 {name=l199 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 4920 120 0 0 {name=l200 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 5270 -120 1 0 {name=l201 sig_type=std_logic lab=Q5}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 5120 120 0 0 {name=X51}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 5240 120 0 0 {name=X52}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 5230 240 3 0 {name=X59 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 5190 240 3 0 {name=l202 lab=VDD}
C {madvlsi/gnd.sym} 5270 240 3 0 {name=l203 lab=GND}
C {devices/lab_pin.sym} 5440 140 2 0 {name=l204 sig_type=std_logic lab=Qn5}
C {devices/lab_pin.sym} 5630 -120 1 0 {name=l205 sig_type=std_logic lab=Q6}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 5490 120 0 0 {name=X60}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 5610 120 0 0 {name=X63}
C {devices/lab_pin.sym} 5810 140 2 0 {name=l206 sig_type=std_logic lab=Qn6}
C {devices/lab_pin.sym} 6000 -120 1 0 {name=l207 sig_type=std_logic lab=Q7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 5860 120 0 0 {name=X68}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 5980 120 0 0 {name=X69}
C {devices/lab_pin.sym} 6180 140 2 0 {name=l208 sig_type=std_logic lab=Qn7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 5600 240 3 0 {name=X70 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 5560 240 3 0 {name=l209 lab=VDD}
C {madvlsi/gnd.sym} 5640 240 3 0 {name=l210 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 5970 240 3 0 {name=X71 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 5930 240 3 0 {name=l211 lab=VDD}
C {madvlsi/gnd.sym} 6010 240 3 0 {name=l212 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 5270 -60 3 0 {name=X72 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 5230 -60 3 0 {name=l213 lab=VDD}
C {madvlsi/gnd.sym} 5310 -60 3 0 {name=l214 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 5630 -60 3 0 {name=X73 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 5590 -60 3 0 {name=l215 lab=VDD}
C {madvlsi/gnd.sym} 5670 -60 3 0 {name=l216 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 6000 -60 3 0 {name=X74 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 5960 -60 3 0 {name=l217 lab=VDD}
C {madvlsi/gnd.sym} 6040 -60 3 0 {name=l218 lab=GND}
C {devices/lab_pin.sym} 5070 320 0 0 {name=l219 sig_type=std_logic lab=Q4}
C {devices/lab_pin.sym} 5440 320 0 0 {name=l220 sig_type=std_logic lab=Q5}
C {devices/lab_pin.sym} 5810 320 0 0 {name=l221 sig_type=std_logic lab=Q6}
C {devices/lab_pin.sym} 5170 120 0 0 {name=l222 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 5170 150 0 0 {name=l223 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 5540 120 0 0 {name=l224 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 5540 150 0 0 {name=l225 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 5910 120 0 0 {name=l226 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 5910 150 0 0 {name=l227 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 5290 150 0 0 {name=l228 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 5290 120 0 0 {name=l229 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 5660 150 0 0 {name=l230 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 5660 120 0 0 {name=l231 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6030 150 0 0 {name=l232 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6030 120 0 0 {name=l233 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6360 -120 1 0 {name=l234 sig_type=std_logic lab=Q8}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6220 120 0 0 {name=X75}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6340 120 0 0 {name=X76}
C {devices/lab_pin.sym} 6540 140 2 0 {name=l235 sig_type=std_logic lab=Qn8}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 6330 240 3 0 {name=X77 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 6290 240 3 0 {name=l236 lab=VDD}
C {madvlsi/gnd.sym} 6370 240 3 0 {name=l237 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 6360 -60 3 0 {name=X78 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 6320 -60 3 0 {name=l238 lab=VDD}
C {madvlsi/gnd.sym} 6400 -60 3 0 {name=l239 lab=GND}
C {devices/lab_pin.sym} 6170 320 0 0 {name=l240 sig_type=std_logic lab=Q7}
C {devices/lab_pin.sym} 6270 120 0 0 {name=l241 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6270 150 0 0 {name=l242 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6390 150 0 0 {name=l243 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6390 120 0 0 {name=l244 sig_type=std_logic lab=C}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2740 530 0 0 {name=X79 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {devices/lab_pin.sym} 2750 550 3 0 {name=l245 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 2730 550 3 0 {name=l246 sig_type=std_logic lab=NP}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2860 530 0 0 {name=X80 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {devices/lab_pin.sym} 2890 530 2 0 {name=l247 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 2870 550 3 0 {name=l248 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 2850 550 3 0 {name=l249 sig_type=std_logic lab=NP}
