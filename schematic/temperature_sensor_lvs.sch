v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 830 -340 880 -340 { lab=#net1}
N 880 -340 1040 -340 { lab=#net1}
N 390 -310 390 -180 { lab=#net2}
N 390 -310 650 -310 { lab=#net2}
N 230 -370 650 -370 { lab=#net3}
N 630 -510 630 -450 { lab=#net1}
N 630 -510 830 -510 { lab=#net1}
N 830 -510 830 -340 { lab=#net1}
N 260 -450 420 -450 { lab=#net1}
N 420 -450 630 -450 { lab=#net1}
N 390 -420 390 -310 { lab=#net2}
N 230 -420 230 -370 { lab=#net3}
N 650 -350 750 -350 { lab=#net3}
N 650 -370 650 -350 { lab=#net3}
N 650 -330 650 -310 { lab=#net2}
N 650 -330 750 -330 { lab=#net2}
N 230 -370 230 -330 { lab=#net3}
N -10 -330 -10 -230 { lab=#net4}
N 230 -230 230 -180 { lab=#net5}
N 1070 -240 1070 -210 { lab=Vben}
N 1070 -310 1070 -240 { lab=Vben}
N 910 -310 910 -210 { lab=Vbep}
N 950 -180 1030 -180 { lab=GND}
N 1070 -150 1070 -90 { lab=GND}
N 910 -150 910 -90 { lab=GND}
N 990 -180 990 -120 { lab=GND}
N 990 -120 990 -90 { lab=GND}
N 940 -180 950 -180 { lab=GND}
N 1030 -180 1040 -180 { lab=GND}
N 1070 -150 1260 -150 { lab=GND}
N 1040 -180 1230 -180 { lab=GND}
N 1070 -210 1260 -210 { lab=Vben}
N 190 -150 190 -120 { lab=GND}
N 190 -120 230 -120 { lab=GND}
N 230 -120 230 -90 { lab=GND}
N 390 -120 390 -90 { lab=GND}
N 350 -90 390 -90 { lab=GND}
N 390 -90 390 -80 { lab=GND}
N 190 -150 200 -150 { lab=GND}
N 350 -150 360 -150 { lab=#net6}
N 880 -370 1030 -370 { lab=VDD}
N 880 -310 1030 -310 { lab=Vbep}
N 350 -480 500 -480 { lab=VDD}
N 350 -420 500 -420 { lab=#net2}
N 860 80 860 110 { lab=Vref}
N 860 110 940 110 { lab=Vref}
N 940 70 940 110 { lab=Vref}
N 740 70 780 70 { lab=Vn}
N 1150 80 1190 80 { lab=Vp}
N 660 80 660 110 { lab=Vn}
N 660 110 740 110 { lab=Vn}
N 740 70 740 110 { lab=Vn}
N 1070 90 1070 120 { lab=Vp}
N 1070 120 1150 120 { lab=Vp}
N 1150 80 1150 120 { lab=Vp}
N 2310 -580 2370 -580 { lab=#net7}
N 2110 -500 2110 -470 { lab=Vnn}
N 2110 -410 2110 -270 { lab=Vnn}
N 2110 -170 2200 -170 { lab=Vnn}
N 2110 -270 2110 -170 { lab=Vnn}
N 2360 -440 2360 -270 { lab=#net7}
N 2260 -170 2360 -170 { lab=#net7}
N 2360 -270 2360 -170 { lab=#net7}
N 1810 -410 1810 -340 { lab=#net8}
N 1790 -410 1830 -410 { lab=#net8}
N 1690 -410 1730 -410 { lab=Vn}
N 1810 -280 1810 -230 { lab=Vref}
N 2070 -410 2110 -410 { lab=Vnn}
N 2110 -470 2110 -410 { lab=Vnn}
N 2360 -580 2360 -440 { lab=#net7}
N 2110 -950 2110 -780 { lab=Vpp}
N 2110 -980 2110 -950 { lab=Vpp}
N 1750 -850 1750 -790 { lab=net9}
N 1730 -790 1770 -790 { lab=net9}
N 1630 -790 1670 -790 { lab=Vp}
N 2250 -950 2310 -950 { lab=Vref}
N 2110 -1080 2110 -1040 { lab=Vref}
N 1750 -950 1750 -910 { lab=Vref}
N 2110 -550 2110 -500 { lab=Vnn}
N 2110 -780 2110 -610 { lab=Vpp}
N 2110 -570 2110 -550 { lab=Vnn}
N 2110 -610 2110 -590 { lab=Vpp}
N 2290 -580 2310 -580 { lab=#net7}
N 2110 -570 2210 -570 { lab=Vnn}
N 2110 -590 2210 -590 { lab=Vpp}
N 2370 -580 2420 -580 { lab=#net7}
N 2420 -580 2510 -580 { lab=#net7}
N 2110 -950 2130 -950 { lab=Vpp}
N 2250 -330 2360 -330 { lab=#net7}
N 2110 -330 2190 -330 { lab=Vnn}
N 2110 -440 2190 -440 { lab=Vnn}
N 2250 -440 2360 -440 { lab=#net7}
N 2190 -950 2190 -890 { lab=Vpp}
N 2130 -950 2190 -950 { lab=Vpp}
N 2250 -950 2250 -890 { lab=Vref}
N 2010 -440 2010 30 { lab=Vnn}
N 1950 -440 1950 30 { lab=#net8}
N 2010 -410 2070 -410 { lab=Vnn}
N 1830 -410 1950 -410 { lab=#net8}
N 1940 -1260 1940 -790 { lab=Vpp}
N 1880 -1260 1880 -790 { lab=net9}
N 1940 -790 2110 -790 { lab=Vpp}
N 1770 -790 1880 -790 { lab=net9}
N 2510 -580 2510 -490 { lab=#net7}
N 2390 1130 2450 1130 { lab=#net10}
N 2190 1210 2190 1240 { lab=Vnn2}
N 2190 1300 2190 1440 { lab=Vnn2}
N 2190 1540 2280 1540 { lab=Vnn2}
N 2190 1440 2190 1540 { lab=Vnn2}
N 2440 1270 2440 1440 { lab=#net10}
N 2340 1540 2440 1540 { lab=#net10}
N 2440 1440 2440 1540 { lab=#net10}
N 1890 1300 1890 1370 { lab=#net11}
N 1870 1300 1910 1300 { lab=#net11}
N 1770 1300 1810 1300 { lab=Vn}
N 1890 1430 1890 1480 { lab=Vref}
N 2150 1300 2190 1300 { lab=Vnn2}
N 2190 1240 2190 1300 { lab=Vnn2}
N 2440 1130 2440 1270 { lab=#net10}
N 2190 760 2190 930 { lab=Vpp2}
N 2190 730 2190 760 { lab=Vpp2}
N 1830 860 1830 920 { lab=net12}
N 1810 920 1850 920 { lab=net12}
N 1710 920 1750 920 { lab=Vp}
N 2330 760 2390 760 { lab=Vref}
N 2190 630 2190 670 { lab=Vref}
N 1830 760 1830 800 { lab=Vref}
N 2190 1160 2190 1210 { lab=Vnn2}
N 2190 930 2190 1100 { lab=Vpp2}
N 2190 1140 2190 1160 { lab=Vnn2}
N 2190 1100 2190 1120 { lab=Vpp2}
N 2370 1130 2390 1130 { lab=#net10}
N 2190 1140 2290 1140 { lab=Vnn2}
N 2190 1120 2290 1120 { lab=Vpp2}
N 2450 1130 2500 1130 { lab=#net10}
N 2500 1130 2590 1130 { lab=#net10}
N 2190 760 2210 760 { lab=Vpp2}
N 2330 1380 2440 1380 { lab=#net10}
N 2190 1380 2270 1380 { lab=Vnn2}
N 2190 1270 2270 1270 { lab=Vnn2}
N 2330 1270 2440 1270 { lab=#net10}
N 2270 760 2270 820 { lab=Vpp2}
N 2210 760 2270 760 { lab=Vpp2}
N 2330 760 2330 820 { lab=Vref}
N 2090 1270 2090 1740 { lab=Vnn2}
N 2030 1270 2030 1740 { lab=#net11}
N 2090 1300 2150 1300 { lab=Vnn2}
N 1910 1300 2030 1300 { lab=#net11}
N 2020 450 2020 920 { lab=Vpp2}
N 1960 450 1960 920 { lab=net12}
N 2020 920 2190 920 { lab=Vpp2}
N 1850 920 1960 920 { lab=net12}
N 2590 1130 2590 1220 { lab=#net10}
N 2590 1280 2590 1360 { lab=#net13}
N 4340 -760 4400 -760 { lab=#net14}
N 4140 -680 4140 -650 { lab=#net15}
N 4140 -590 4140 -450 { lab=#net15}
N 4140 -350 4230 -350 { lab=#net15}
N 4140 -450 4140 -350 { lab=#net15}
N 4390 -620 4390 -450 { lab=#net14}
N 4290 -350 4390 -350 { lab=#net14}
N 4390 -450 4390 -350 { lab=#net14}
N 3840 -590 3840 -520 { lab=#net16}
N 3820 -590 3860 -590 { lab=#net16}
N 3720 -590 3760 -590 { lab=Vn}
N 3840 -460 3840 -410 { lab=Vouts}
N 4100 -590 4140 -590 { lab=#net15}
N 4140 -650 4140 -590 { lab=#net15}
N 4390 -760 4390 -620 { lab=#net14}
N 4140 -1130 4140 -960 { lab=#net17}
N 4140 -1160 4140 -1130 { lab=#net17}
N 3780 -1030 3780 -970 { lab=#net18}
N 3760 -970 3800 -970 { lab=#net18}
N 3660 -970 3700 -970 { lab=Vp}
N 4280 -1130 4340 -1130 { lab=Vouts}
N 4140 -1260 4140 -1220 { lab=Vouts}
N 3780 -1130 3780 -1090 { lab=Vouts}
N 4140 -730 4140 -680 { lab=#net15}
N 4140 -960 4140 -790 { lab=#net17}
N 4140 -750 4140 -730 { lab=#net15}
N 4140 -790 4140 -770 { lab=#net17}
N 4320 -760 4340 -760 { lab=#net14}
N 4140 -750 4240 -750 { lab=#net15}
N 4140 -770 4240 -770 { lab=#net17}
N 4400 -760 4450 -760 { lab=#net14}
N 4450 -760 4540 -760 { lab=#net14}
N 4140 -1130 4160 -1130 { lab=#net17}
N 4280 -510 4390 -510 { lab=#net14}
N 4140 -510 4220 -510 { lab=#net15}
N 4140 -620 4220 -620 { lab=#net15}
N 4280 -620 4390 -620 { lab=#net14}
N 4220 -1130 4220 -1070 { lab=#net17}
N 4160 -1130 4220 -1130 { lab=#net17}
N 4280 -1130 4280 -1070 { lab=Vouts}
N 4040 -620 4040 -150 { lab=#net15}
N 3980 -620 3980 -150 { lab=#net16}
N 4040 -590 4100 -590 { lab=#net15}
N 3860 -590 3980 -590 { lab=#net16}
N 3970 -1440 3970 -970 { lab=#net17}
N 3910 -1440 3910 -970 { lab=#net18}
N 3970 -970 4140 -970 { lab=#net17}
N 3800 -970 3910 -970 { lab=#net18}
N 4540 -760 4540 -670 { lab=#net14}
N 4420 950 4480 950 { lab=#net19}
N 4220 1030 4220 1060 { lab=#net20}
N 4220 1120 4220 1260 { lab=#net20}
N 4220 1360 4310 1360 { lab=#net20}
N 4220 1260 4220 1360 { lab=#net20}
N 4470 1090 4470 1260 { lab=#net19}
N 4370 1360 4470 1360 { lab=#net19}
N 4470 1260 4470 1360 { lab=#net19}
N 3920 1120 3920 1190 { lab=#net21}
N 3900 1120 3940 1120 { lab=#net21}
N 3800 1120 3840 1120 { lab=Vn}
N 3920 1250 3920 1300 { lab=Vouts}
N 4180 1120 4220 1120 { lab=#net20}
N 4220 1060 4220 1120 { lab=#net20}
N 4470 950 4470 1090 { lab=#net19}
N 4220 580 4220 750 { lab=#net22}
N 4220 550 4220 580 { lab=#net22}
N 3860 680 3860 740 { lab=#net23}
N 3840 740 3880 740 { lab=#net23}
N 3740 740 3780 740 { lab=Vp}
N 4360 580 4420 580 { lab=Vouts}
N 4220 450 4220 490 { lab=Vouts}
N 3860 580 3860 620 { lab=Vouts}
N 4220 980 4220 1030 { lab=#net20}
N 4220 750 4220 920 { lab=#net22}
N 4220 960 4220 980 { lab=#net20}
N 4220 920 4220 940 { lab=#net22}
N 4400 950 4420 950 { lab=#net19}
N 4220 960 4320 960 { lab=#net20}
N 4220 940 4320 940 { lab=#net22}
N 4480 950 4530 950 { lab=#net19}
N 4530 950 4620 950 { lab=#net19}
N 4220 580 4240 580 { lab=#net22}
N 4360 1200 4470 1200 { lab=#net19}
N 4220 1200 4300 1200 { lab=#net20}
N 4220 1090 4300 1090 { lab=#net20}
N 4360 1090 4470 1090 { lab=#net19}
N 4300 580 4300 640 { lab=#net22}
N 4240 580 4300 580 { lab=#net22}
N 4360 580 4360 640 { lab=Vouts}
N 4120 1090 4120 1560 { lab=#net20}
N 4060 1090 4060 1560 { lab=#net21}
N 4120 1120 4180 1120 { lab=#net20}
N 3940 1120 4060 1120 { lab=#net21}
N 4050 270 4050 740 { lab=#net22}
N 3990 270 3990 740 { lab=#net23}
N 4050 740 4220 740 { lab=#net22}
N 3880 740 3990 740 { lab=#net23}
N 4620 950 4620 1040 { lab=#net19}
N 2590 1360 2700 1360 { lab=#net13}
N 2700 -340 2700 1360 { lab=#net13}
N 2510 -340 2700 -340 { lab=#net13}
N 2510 -430 2510 -340 { lab=#net13}
N 4620 1100 4620 1180 { lab=#net24}
N 4620 1180 4730 1180 { lab=#net24}
N 4730 -520 4730 1180 { lab=#net24}
N 4540 -520 4730 -520 { lab=#net24}
N 4540 -610 4540 -520 { lab=#net24}
N 3480 230 3480 280 { lab=Vouts}
N 3400 240 3400 280 { lab=#net25}
N 3380 220 3400 220 { lab=#net26}
N 3400 280 3400 320 { lab=#net25}
N 3400 210 3400 220 { lab=#net26}
N 3400 320 3400 660 { lab=#net25}
N 3400 660 3480 660 { lab=#net25}
N 3480 640 3480 660 { lab=#net25}
N 3460 310 3460 610 { lab=GND}
N 3380 -120 3380 180 { lab=GND}
N 3390 660 3400 660 { lab=#net25}
N 2930 290 3350 290 { lab=GND}
N 2900 660 3330 660 { lab=GND}
N 3380 310 3400 310 { lab=#net25}
N 2930 200 3350 200 { lab=GND}
N 2900 310 2900 660 { lab=GND}
N 3390 790 3400 790 { lab=#net25}
N 3400 660 3400 790 { lab=#net25}
N 3310 790 3330 790 { lab=GND}
N 3310 660 3310 790 { lab=GND}
N 2700 220 2900 220 { lab=#net13}
N 2560 -200 2560 270 { lab=#net13}
N 2500 -200 2500 270 { lab=GND}
N 2560 400 2560 870 { lab=#net13}
N 2500 400 2500 870 { lab=GND}
N 2560 590 2700 590 { lab=#net13}
N 2560 90 2700 90 { lab=#net13}
N 2460 60 2500 60 { lab=GND}
N 2460 400 2500 400 { lab=GND}
N 2020 450 2020 920 { lab=Vpp2}
N 1960 450 1960 920 { lab=net12}
N 2270 130 2270 190 { lab=#net27}
N 2330 130 2330 190 { lab=#net28}
N 2270 310 2270 370 { lab=#net29}
N 2330 310 2330 370 { lab=#net30}
N 4210 -10 4210 50 { lab=#net31}
N 4270 -10 4270 50 { lab=#net32}
N 4210 170 4210 230 { lab=#net33}
N 4270 170 4270 230 { lab=#net34}
N 4620 -260 4620 210 { lab=#net24}
N 4560 -260 4560 210 { lab=GND}
N 4620 340 4620 810 { lab=#net24}
N 4560 340 4560 810 { lab=GND}
N 4520 0 4560 0 { lab=GND}
N 4520 340 4560 340 { lab=GND}
N 4620 580 4730 580 { lab=#net24}
N 4620 -10 4730 -10 { lab=#net24}
N 5540 -120 5560 -120 { lab=#net35}
N 5500 -120 5540 -120 { lab=#net35}
N 5520 -120 5520 -30 { lab=#net35}
N 5410 -110 5410 -30 { lab=#net36}
N 5640 -130 5720 -130 { lab=Vflag}
N 5880 400 7530 400 { lab=Vflag}
N 7530 380 7530 400 { lab=Vflag}
N 7330 380 7330 400 { lab=Vflag}
N 7110 380 7110 400 { lab=Vflag}
N 6910 380 6910 400 { lab=Vflag}
N 6710 380 6710 400 { lab=Vflag}
N 6510 380 6510 400 { lab=Vflag}
N 6300 380 6300 400 { lab=Vflag}
N 6100 380 6100 400 { lab=Vflag}
N 6100 -260 6100 -240 { lab=#net37}
N 6130 -350 6160 -350 { lab=#net38}
N 6250 -300 6310 -300 { lab=Qn0}
N 6310 -440 6310 -300 { lab=Qn0}
N 6010 -440 6310 -440 { lab=Qn0}
N 6010 -440 6010 -350 { lab=Qn0}
N 6010 -350 6040 -350 { lab=Qn0}
N 6220 -260 6220 -240 { lab=#net39}
N 6220 -140 6220 -120 { lab=#net37}
N 6100 -120 6220 -120 { lab=#net37}
N 6500 -350 6530 -350 { lab=#net40}
N 6620 -300 6680 -300 { lab=Qn1}
N 6680 -440 6680 -300 { lab=Qn1}
N 6380 -440 6680 -440 { lab=Qn1}
N 6380 -440 6380 -350 { lab=Qn1}
N 6380 -350 6410 -350 { lab=Qn1}
N 6870 -350 6900 -350 { lab=#net41}
N 6990 -300 7050 -300 { lab=Qn2}
N 7050 -440 7050 -300 { lab=Qn2}
N 6750 -440 7050 -440 { lab=Qn2}
N 6750 -440 6750 -350 { lab=Qn2}
N 6750 -350 6780 -350 { lab=Qn2}
N 7240 -350 7270 -350 { lab=#net42}
N 7360 -300 7420 -300 { lab=Qn3}
N 7420 -440 7420 -300 { lab=Qn3}
N 7120 -440 7420 -440 { lab=Qn3}
N 7120 -440 7120 -350 { lab=Qn3}
N 7120 -350 7150 -350 { lab=Qn3}
N 6590 -260 6590 -120 { lab=Q0}
N 6310 -120 6590 -120 { lab=Q0}
N 6470 -160 6470 -120 { lab=Q0}
N 6960 -260 6960 -120 { lab=Q1}
N 6680 -120 6960 -120 { lab=Q1}
N 6840 -160 6840 -120 { lab=Q1}
N 7330 -260 7330 -120 { lab=Q2}
N 7050 -120 7330 -120 { lab=Q2}
N 7210 -160 7210 -120 { lab=Q2}
N 6150 -460 6150 -350 { lab=#net38}
N 6510 -460 6510 -350 { lab=#net40}
N 6870 -460 6870 -350 { lab=#net41}
N 7240 -460 7240 -350 { lab=#net42}
N 6100 -140 6100 -120 { lab=#net37}
N 6100 -240 6100 -140 { lab=#net37}
N 7610 -350 7640 -350 { lab=#net43}
N 7730 -300 7790 -300 { lab=Qn4}
N 7790 -440 7790 -300 { lab=Qn4}
N 7490 -440 7790 -440 { lab=Qn4}
N 7490 -440 7490 -350 { lab=Qn4}
N 7490 -350 7520 -350 { lab=Qn4}
N 7700 -260 7700 -120 { lab=Q3}
N 7420 -120 7700 -120 { lab=Q3}
N 7580 -160 7580 -120 { lab=Q3}
N 7610 -460 7610 -350 { lab=#net43}
N 7980 -350 8010 -350 { lab=#net44}
N 8100 -300 8160 -300 { lab=Qn5}
N 8160 -440 8160 -300 { lab=Qn5}
N 7860 -440 8160 -440 { lab=Qn5}
N 7860 -440 7860 -350 { lab=Qn5}
N 7860 -350 7890 -350 { lab=Qn5}
N 8350 -350 8380 -350 { lab=#net45}
N 8470 -300 8530 -300 { lab=Qn6}
N 8530 -440 8530 -300 { lab=Qn6}
N 8230 -440 8530 -440 { lab=Qn6}
N 8230 -440 8230 -350 { lab=Qn6}
N 8230 -350 8260 -350 { lab=Qn6}
N 8720 -350 8750 -350 { lab=#net46}
N 8840 -300 8900 -300 { lab=Qn7}
N 8900 -440 8900 -300 { lab=Qn7}
N 8600 -440 8900 -440 { lab=Qn7}
N 8600 -440 8600 -350 { lab=Qn7}
N 8600 -350 8630 -350 { lab=Qn7}
N 8070 -260 8070 -120 { lab=Q4}
N 7790 -120 8070 -120 { lab=Q4}
N 7950 -160 7950 -120 { lab=Q4}
N 8440 -260 8440 -120 { lab=Q5}
N 8160 -120 8440 -120 { lab=Q5}
N 8320 -160 8320 -120 { lab=Q5}
N 8810 -260 8810 -120 { lab=Q6}
N 8530 -120 8810 -120 { lab=Q6}
N 8690 -160 8690 -120 { lab=Q6}
N 7990 -460 7990 -350 { lab=#net44}
N 8350 -460 8350 -350 { lab=#net45}
N 8720 -460 8720 -350 { lab=#net46}
N 9080 -350 9110 -350 { lab=#net47}
N 9200 -300 9260 -300 { lab=Qn8}
N 9260 -440 9260 -300 { lab=Qn8}
N 8960 -440 9260 -440 { lab=Qn8}
N 8960 -440 8960 -350 { lab=Qn8}
N 8960 -350 8990 -350 { lab=Qn8}
N 9170 -260 9170 -120 { lab=Q7}
N 8890 -120 9170 -120 { lab=Q7}
N 9050 -160 9050 -120 { lab=Q7}
N 9080 -460 9080 -350 { lab=#net47}
N 5490 90 5520 90 { lab=#net35}
N 5520 -30 5520 90 { lab=#net35}
N 5410 -30 5410 90 { lab=#net36}
N 5410 90 5430 90 { lab=#net36}
N 5520 90 5550 90 { lab=#net35}
N 5410 -110 5420 -110 { lab=#net36}
N 5880 -140 5880 -100 { lab=#net48}
N 6010 -140 6010 -100 { lab=#net37}
N 5840 -170 5850 -170 { lab=#net49}
N 5840 -170 5840 -70 { lab=#net49}
N 5840 -70 5850 -70 { lab=#net49}
N 5970 -170 5980 -170 { lab=#net48}
N 5970 -170 5970 -70 { lab=#net48}
N 5970 -70 5980 -70 { lab=#net48}
N 5880 -120 5970 -120 { lab=#net48}
N 6010 -120 6100 -120 { lab=#net37}
N 5790 -120 5840 -120 { lab=#net49}
N 4730 -20 5070 -20 { lab=#net24}
N 1190 80 1460 80 { lab=Vp}
N 1460 -790 1460 80 { lab=Vp}
N 1460 -790 1630 -790 { lab=Vp}
N 740 110 740 270 { lab=Vn}
N 740 270 1710 270 { lab=Vn}
N 1710 -410 1710 270 { lab=Vn}
C {madvlsi/vdd.sym} 910 -370 0 0 {name=l2 lab=VDD}
C {madvlsi/vdd.sym} 1070 -370 0 0 {name=l5 lab=VDD}
C {madvlsi/pmos3.sym} 910 -340 0 0 {name=M1
L=0.6
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1070 -340 0 0 {name=M2
L=0.6
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 230 -450 0 1 {name=M3
L=0.6
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 390 -480 0 0 {name=l21 lab=VDD}
C {madvlsi/vdd.sym} 230 -480 0 0 {name=l22 lab=VDD}
C {sky130_fd_pr/res_xhigh_po.sym} 200 -330 1 0 {name=R3
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 200 -350 2 0 {name=l1 lab=GND}
C {sky130_fd_pr/res_xhigh_po.sym} 140 -330 1 0 {name=R1
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 140 -350 2 0 {name=l3 lab=GND}
C {sky130_fd_pr/res_xhigh_po.sym} 80 -330 1 0 {name=R4
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 80 -350 2 0 {name=l4 lab=GND}
C {sky130_fd_pr/res_xhigh_po.sym} 20 -330 1 0 {name=R5
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 20 -350 2 0 {name=l6 lab=GND}
C {sky130_fd_pr/res_xhigh_po.sym} 200 -230 1 0 {name=R6
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 200 -250 2 0 {name=l7 lab=GND}
C {sky130_fd_pr/res_xhigh_po.sym} 140 -230 1 0 {name=R7
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 140 -250 2 0 {name=l8 lab=GND}
C {sky130_fd_pr/res_xhigh_po.sym} 80 -230 1 0 {name=R8
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 80 -250 2 0 {name=l9 lab=GND}
C {sky130_fd_pr/res_xhigh_po.sym} 20 -230 1 0 {name=R9
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 20 -250 2 0 {name=l12 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage_lvs.sym} 790 -340 0 0 {name=X1}
C {devices/lab_pin.sym} 910 -260 0 0 {name=l16 sig_type=std_logic lab=Vbep}
C {devices/lab_pin.sym} 1070 -260 0 0 {name=l17 sig_type=std_logic lab=Vben}
C {madvlsi/gnd.sym} 1070 -90 0 1 {name=l27 lab=GND}
C {madvlsi/gnd.sym} 910 -90 0 1 {name=l28 lab=GND}
C {madvlsi/gnd.sym} 990 -90 0 1 {name=l29 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 910 -180 0 1 {name=XQ3
model=W0p68L0p68}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 1070 -180 0 0 {name=XQ4
model=W0p68L0p68}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 1100 -180 0 0 {name=XQ5
model=W0p68L0p68}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 1130 -180 0 0 {name=XQ6
model=W0p68L0p68}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 1160 -180 0 0 {name=XQ7
model=W0p68L0p68}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 1180 -180 0 0 {name=XQ8
model=W0p68L0p68}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 1200 -180 0 0 {name=XQ9
model=W0p68L0p68}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 1220 -180 0 0 {name=XQ10
model=W0p68L0p68}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 1240 -180 0 0 {name=XQ11
model=W0p68L0p68}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 150 60 0 0 {name=XQ13
model=W0p68L0p68}
C {madvlsi/gnd.sym} 150 90 0 1 {name=l25 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 230 60 0 0 {name=XQ14
model=W0p68L0p68}
C {madvlsi/gnd.sym} 230 90 0 1 {name=l26 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 300 60 0 0 {name=XQ15
model=W0p68L0p68}
C {madvlsi/gnd.sym} 300 90 0 1 {name=l32 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 370 60 0 0 {name=XQ16
model=W0p68L0p68}
C {madvlsi/gnd.sym} 370 90 0 1 {name=l33 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 450 60 0 0 {name=XQ17
model=W0p68L0p68}
C {madvlsi/gnd.sym} 450 90 0 1 {name=l34 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 150 180 0 0 {name=XQ18
model=W0p68L0p68}
C {madvlsi/gnd.sym} 150 210 0 1 {name=l10 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 230 180 0 0 {name=XQ19
model=W0p68L0p68}
C {madvlsi/gnd.sym} 230 210 0 1 {name=l11 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 300 180 0 0 {name=XQ20
model=W0p68L0p68}
C {madvlsi/gnd.sym} 300 210 0 1 {name=l13 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 370 180 0 0 {name=XQ21
model=W0p68L0p68}
C {madvlsi/gnd.sym} 370 210 0 1 {name=l18 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 450 180 0 0 {name=XQ22
model=W0p68L0p68}
C {madvlsi/gnd.sym} 450 210 0 1 {name=l23 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 150 300 0 0 {name=XQ23
model=W0p68L0p68}
C {madvlsi/gnd.sym} 150 330 0 1 {name=l24 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 230 300 0 0 {name=XQ24
model=W0p68L0p68}
C {madvlsi/gnd.sym} 230 330 0 1 {name=l30 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 300 300 0 0 {name=XQ25
model=W0p68L0p68}
C {madvlsi/gnd.sym} 300 330 0 1 {name=l31 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 370 300 0 0 {name=XQ26
model=W0p68L0p68}
C {madvlsi/gnd.sym} 370 330 0 1 {name=l35 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 450 300 0 0 {name=XQ27
model=W0p68L0p68}
C {madvlsi/gnd.sym} 450 330 0 1 {name=l36 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 150 430 0 0 {name=XQ28
model=W0p68L0p68}
C {madvlsi/gnd.sym} 150 460 0 1 {name=l37 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 230 430 0 0 {name=XQ29
model=W0p68L0p68}
C {madvlsi/gnd.sym} 230 460 0 1 {name=l38 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 300 430 0 0 {name=XQ30
model=W0p68L0p68}
C {madvlsi/gnd.sym} 300 460 0 1 {name=l39 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 370 430 0 0 {name=XQ31
model=W0p68L0p68}
C {madvlsi/gnd.sym} 370 460 0 1 {name=l40 lab=GND}
C {madvlsi/gnd.sym} 230 -90 0 0 {name=l19 lab=GND}
C {madvlsi/gnd.sym} 390 -80 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/res_xhigh_po.sym} 350 -120 0 0 {name=R2
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 330 -120 0 0 {name=l14 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 230 -150 0 0 {name=XQ1
model=W0p68L0p68}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/sky130_fd_pr__pnp_stuff/sky130_fd_pr__pnp_05v0.sym} 390 -150 0 0 {name=XQ2
model=W0p68L0p68}
C {madvlsi/pmos3.sym} 930 -340 0 0 {name=M5
L=0.6
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 950 -340 0 0 {name=M6
L=0.6
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 970 -340 0 0 {name=M7
L=0.6
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 990 -340 0 0 {name=M8
L=0.6
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1010 -340 0 0 {name=M9
L=0.6
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1030 -340 0 0 {name=M10
L=0.6
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 880 -340 0 0 {name=M11
L=0.6
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 380 -450 0 0 {name=M4
L=0.6
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 400 -450 0 0 {name=M12
L=0.6
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 420 -450 0 0 {name=M13
L=0.6
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 440 -450 0 0 {name=M14
L=0.6
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 460 -450 0 0 {name=M15
L=0.6
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 480 -450 0 0 {name=M16
L=0.6
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 500 -450 0 0 {name=M17
L=0.6
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 350 -450 0 0 {name=M18
L=0.6
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 940 70 2 0 {name=l56 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 860 60 0 0 {name=l15 sig_type=std_logic lab=Vben}
C {devices/lab_pin.sym} 1150 80 1 0 {name=l91 sig_type=std_logic lab=Vp}
C {devices/lab_pin.sym} 740 70 1 0 {name=l92 sig_type=std_logic lab=Vn}
C {devices/lab_pin.sym} 660 60 0 0 {name=l111 sig_type=std_logic lab=Vbep}
C {devices/lab_pin.sym} 1070 70 0 0 {name=l112 sig_type=std_logic lab=Vben}
C {devices/lab_pin.sym} 1070 70 0 0 {name=l113 sig_type=std_logic lab=Vben}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage_lvs.sym} 700 70 0 0 {name=X2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage_lvs.sym} 900 70 0 0 {name=X3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage_lvs.sym} 1110 80 0 0 {name=X4}
C {devices/lab_pin.sym} 2110 -650 0 0 {name=l41 sig_type=std_logic lab=Vpp}
C {devices/lab_pin.sym} 2110 -500 0 0 {name=l42 sig_type=std_logic lab=Vnn}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1760 -410 0 0 {name=X10}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1810 -310 3 0 {name=X11}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2230 -170 0 0 {name=X12}
C {devices/lab_pin.sym} 1810 -230 3 0 {name=l43 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 2220 -150 3 0 {name=l44 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 2240 -150 3 0 {name=l45 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 1750 -390 3 0 {name=l46 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 1770 -390 3 0 {name=l50 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 1830 -300 2 0 {name=l51 sig_type=std_logic lab=Vphi2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1700 -790 0 0 {name=X5}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1750 -880 1 0 {name=X7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2110 -1010 1 0 {name=X9}
C {devices/lab_pin.sym} 2110 -1080 1 0 {name=l47 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 1750 -950 1 0 {name=l48 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 1690 -770 3 0 {name=l49 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 1710 -770 3 0 {name=l52 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 1730 -890 0 0 {name=l53 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 1730 -870 0 0 {name=l54 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 2310 -950 2 0 {name=l55 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 1830 -320 2 0 {name=l57 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 1630 -790 1 0 {name=l58 sig_type=std_logic lab=Vp}
C {devices/lab_pin.sym} 1690 -410 1 0 {name=l59 sig_type=std_logic lab=Vn}
C {devices/lab_pin.sym} 2090 -1020 0 0 {name=l60 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 2090 -1000 0 0 {name=l61 sig_type=std_logic lab=Vnphi1}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2220 -890 3 0 {name=C1 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage_lvs.sym} 2250 -580 0 0 {name=X6}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2220 -950 3 0 {name=C3 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2220 -440 3 0 {name=C4 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2220 -330 3 0 {name=C6 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1980 -410 1 0 {name=C5 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1980 -440 1 0 {name=C7 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1980 -340 1 0 {name=C8 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1980 -370 1 0 {name=C9 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1980 -280 1 0 {name=C10 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1980 -310 1 0 {name=C11 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1980 -220 1 0 {name=C12 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1980 -250 1 0 {name=C13 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1980 -150 1 0 {name=C14 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1980 -180 1 0 {name=C15 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1980 -90 1 0 {name=C16 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1980 -120 1 0 {name=C17 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1980 -30 1 0 {name=C18 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1980 -60 1 0 {name=C19 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1980 30 1 0 {name=C20 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1980 0 1 0 {name=C21 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1910 -1230 1 0 {name=C22 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1910 -1260 1 0 {name=C23 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1910 -1160 1 0 {name=C24 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1910 -1190 1 0 {name=C25 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1910 -1100 1 0 {name=C26 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1910 -1130 1 0 {name=C27 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1910 -1040 1 0 {name=C28 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1910 -1070 1 0 {name=C29 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1910 -970 1 0 {name=C30 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1910 -1000 1 0 {name=C31 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1910 -910 1 0 {name=C32 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1910 -940 1 0 {name=C33 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1910 -850 1 0 {name=C34 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1910 -880 1 0 {name=C35 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1910 -790 1 0 {name=C36 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1910 -820 1 0 {name=C37 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2510 -460 1 0 {name=X20}
C {devices/lab_pin.sym} 2490 -470 0 0 {name=l70 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 2490 -450 0 0 {name=l71 sig_type=std_logic lab=Vnphi2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1840 1300 0 0 {name=X8}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1890 1400 3 0 {name=X13}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2310 1540 0 0 {name=X14}
C {devices/lab_pin.sym} 1890 1480 3 0 {name=l62 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 2300 1560 3 0 {name=l63 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 2320 1560 3 0 {name=l64 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 1830 1320 3 0 {name=l65 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 1850 1320 3 0 {name=l66 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 1910 1410 2 0 {name=l67 sig_type=std_logic lab=Vphi1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1780 920 0 0 {name=X15}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 1830 830 1 0 {name=X16}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2190 700 1 0 {name=X17}
C {devices/lab_pin.sym} 2190 630 1 0 {name=l68 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 1830 760 1 0 {name=l69 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 1770 940 3 0 {name=l72 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 1790 940 3 0 {name=l73 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 1810 820 0 0 {name=l74 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 1810 840 0 0 {name=l75 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 2390 760 2 0 {name=l76 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 1910 1390 2 0 {name=l77 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 1710 920 1 0 {name=l78 sig_type=std_logic lab=Vp}
C {devices/lab_pin.sym} 1770 1300 1 0 {name=l79 sig_type=std_logic lab=Vn}
C {devices/lab_pin.sym} 2170 690 0 0 {name=l80 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 2170 710 0 0 {name=l81 sig_type=std_logic lab=Vnphi2}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2300 820 3 0 {name=C2 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage_lvs.sym} 2330 1130 0 0 {name=X18}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2300 760 3 0 {name=C38 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2300 1270 3 0 {name=C39 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2300 1380 3 0 {name=C40 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2060 1300 1 0 {name=C41 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2060 1270 1 0 {name=C42 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2060 1370 1 0 {name=C43 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2060 1340 1 0 {name=C44 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2060 1430 1 0 {name=C45 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2060 1400 1 0 {name=C46 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2060 1490 1 0 {name=C47 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2060 1460 1 0 {name=C48 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2060 1560 1 0 {name=C49 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2060 1530 1 0 {name=C50 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2060 1620 1 0 {name=C51 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2060 1590 1 0 {name=C52 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2060 1680 1 0 {name=C53 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2060 1650 1 0 {name=C54 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2060 1740 1 0 {name=C55 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2060 1710 1 0 {name=C56 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 480 1 0 {name=C57 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 450 1 0 {name=C58 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 550 1 0 {name=C59 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 520 1 0 {name=C60 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 610 1 0 {name=C61 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 580 1 0 {name=C62 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 670 1 0 {name=C63 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 640 1 0 {name=C64 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 740 1 0 {name=C65 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 710 1 0 {name=C66 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 800 1 0 {name=C67 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 770 1 0 {name=C68 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 860 1 0 {name=C69 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 830 1 0 {name=C70 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 920 1 0 {name=C71 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 890 1 0 {name=C72 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 2590 1250 1 0 {name=X19}
C {devices/lab_pin.sym} 2570 1240 0 0 {name=l82 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 2570 1260 0 0 {name=l83 sig_type=std_logic lab=Vnphi1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 3790 -590 0 0 {name=X21}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 3840 -490 3 0 {name=X22}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 4260 -350 0 0 {name=X23}
C {devices/lab_pin.sym} 4250 -330 3 0 {name=l84 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 4270 -330 3 0 {name=l85 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 3780 -570 3 0 {name=l86 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 3800 -570 3 0 {name=l87 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 3860 -480 2 0 {name=l88 sig_type=std_logic lab=Vphi2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 3730 -970 0 0 {name=X24}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 3780 -1060 1 0 {name=X25}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 4140 -1190 1 0 {name=X26}
C {devices/lab_pin.sym} 3720 -950 3 0 {name=l89 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 3740 -950 3 0 {name=l90 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 3760 -1070 0 0 {name=l93 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 3760 -1050 0 0 {name=l94 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 3860 -500 2 0 {name=l95 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 3660 -970 1 0 {name=l96 sig_type=std_logic lab=Vp}
C {devices/lab_pin.sym} 3720 -590 1 0 {name=l97 sig_type=std_logic lab=Vn}
C {devices/lab_pin.sym} 4120 -1200 0 0 {name=l98 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 4120 -1180 0 0 {name=l99 sig_type=std_logic lab=Vnphi1}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4250 -1070 3 0 {name=C73 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage_lvs.sym} 4280 -760 0 0 {name=X27}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4250 -1130 3 0 {name=C74 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4250 -620 3 0 {name=C75 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4250 -510 3 0 {name=C76 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4010 -590 1 0 {name=C77 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4010 -620 1 0 {name=C78 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4010 -520 1 0 {name=C79 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4010 -550 1 0 {name=C80 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4010 -460 1 0 {name=C81 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4010 -490 1 0 {name=C82 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4010 -400 1 0 {name=C83 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4010 -430 1 0 {name=C84 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4010 -330 1 0 {name=C85 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4010 -360 1 0 {name=C86 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4010 -270 1 0 {name=C87 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4010 -300 1 0 {name=C88 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4010 -210 1 0 {name=C89 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4010 -240 1 0 {name=C90 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4010 -150 1 0 {name=C91 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4010 -180 1 0 {name=C92 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3940 -1410 1 0 {name=C93 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3940 -1440 1 0 {name=C94 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3940 -1340 1 0 {name=C95 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3940 -1370 1 0 {name=C96 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3940 -1280 1 0 {name=C97 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3940 -1310 1 0 {name=C98 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3940 -1220 1 0 {name=C99 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3940 -1250 1 0 {name=C100 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3940 -1150 1 0 {name=C101 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3940 -1180 1 0 {name=C102 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3940 -1090 1 0 {name=C103 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3940 -1120 1 0 {name=C104 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3940 -1030 1 0 {name=C105 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3940 -1060 1 0 {name=C106 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3940 -970 1 0 {name=C107 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3940 -1000 1 0 {name=C108 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 4540 -640 1 0 {name=X28}
C {devices/lab_pin.sym} 4520 -650 0 0 {name=l100 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 4520 -630 0 0 {name=l101 sig_type=std_logic lab=Vnphi2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 3870 1120 0 0 {name=X29}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 3920 1220 3 0 {name=X30}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 4340 1360 0 0 {name=X31}
C {devices/lab_pin.sym} 4330 1380 3 0 {name=l102 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 4350 1380 3 0 {name=l103 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 3860 1140 3 0 {name=l104 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 3880 1140 3 0 {name=l105 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 3940 1230 2 0 {name=l106 sig_type=std_logic lab=Vphi1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 3810 740 0 0 {name=X32}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 3860 650 1 0 {name=X33}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 4220 520 1 0 {name=X34}
C {devices/lab_pin.sym} 3800 760 3 0 {name=l107 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 3820 760 3 0 {name=l108 sig_type=std_logic lab=Vnphi2}
C {devices/lab_pin.sym} 3840 640 0 0 {name=l109 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 3840 660 0 0 {name=l110 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 3940 1210 2 0 {name=l114 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 3740 740 1 0 {name=l115 sig_type=std_logic lab=Vp}
C {devices/lab_pin.sym} 3800 1120 1 0 {name=l116 sig_type=std_logic lab=Vn}
C {devices/lab_pin.sym} 4200 510 0 0 {name=l117 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 4200 530 0 0 {name=l118 sig_type=std_logic lab=Vnphi2}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4330 640 3 0 {name=C109 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage_lvs.sym} 4360 950 0 0 {name=X35}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4330 580 3 0 {name=C110 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4330 1090 3 0 {name=C111 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4330 1200 3 0 {name=C112 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4090 1120 1 0 {name=C113 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4090 1090 1 0 {name=C114 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4090 1190 1 0 {name=C115 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4090 1160 1 0 {name=C116 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4090 1250 1 0 {name=C117 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4090 1220 1 0 {name=C118 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4090 1310 1 0 {name=C119 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4090 1280 1 0 {name=C120 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4090 1380 1 0 {name=C121 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4090 1350 1 0 {name=C122 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4090 1440 1 0 {name=C123 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4090 1410 1 0 {name=C124 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4090 1500 1 0 {name=C125 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4090 1470 1 0 {name=C126 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4090 1560 1 0 {name=C127 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4090 1530 1 0 {name=C128 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4020 300 1 0 {name=C129 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4020 270 1 0 {name=C130 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4020 370 1 0 {name=C131 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4020 340 1 0 {name=C132 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4020 430 1 0 {name=C133 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4020 400 1 0 {name=C134 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4020 490 1 0 {name=C135 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4020 460 1 0 {name=C136 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4020 560 1 0 {name=C137 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4020 530 1 0 {name=C138 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4020 620 1 0 {name=C139 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4020 590 1 0 {name=C140 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4020 680 1 0 {name=C141 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4020 650 1 0 {name=C142 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4020 740 1 0 {name=C143 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4020 710 1 0 {name=C144 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 4620 1070 1 0 {name=X36}
C {devices/lab_pin.sym} 4600 1060 0 0 {name=l119 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 4600 1080 0 0 {name=l120 sig_type=std_logic lab=Vnphi1}
C {devices/lab_pin.sym} 3480 230 2 0 {name=l121 sig_type=std_logic lab=Vouts}
C {madvlsi/gnd.sym} 2900 310 1 1 {name=l122 lab=GND}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3360 790 1 0 {name=C145 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage_lvs.sym} 3440 230 0 0 {name=X37}
C {sky130_fd_pr/res_xhigh_po.sym} 3480 310 0 0 {name=R10
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3350 310 1 0 {name=R11
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3480 370 0 0 {name=R12
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3480 430 0 0 {name=R13
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3480 490 0 0 {name=R14
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3480 550 0 0 {name=R15
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3480 610 0 0 {name=R16
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 3460 610 1 1 {name=l123 lab=GND}
C {sky130_fd_pr/res_xhigh_po.sym} 3400 -120 0 0 {name=R17
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3400 -60 0 0 {name=R18
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3400 0 0 0 {name=R19
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3400 60 0 0 {name=R20
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3400 120 0 0 {name=R21
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3400 180 0 0 {name=R22
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 3380 -120 1 1 {name=l124 lab=GND}
C {madvlsi/gnd.sym} 3400 -150 2 1 {name=l125 lab=GND}
C {sky130_fd_pr/res_xhigh_po.sym} 3290 310 1 0 {name=R23
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3230 310 1 0 {name=R24
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3170 310 1 0 {name=R25
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3110 310 1 0 {name=R26
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3050 310 1 0 {name=R27
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 2990 310 1 0 {name=R28
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 2930 310 1 0 {name=R29
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 2930 290 2 1 {name=l126 lab=GND}
C {sky130_fd_pr/res_xhigh_po.sym} 3350 220 1 0 {name=R30
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3290 220 1 0 {name=R31
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3230 220 1 0 {name=R32
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3170 220 1 0 {name=R33
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3110 220 1 0 {name=R34
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 3050 220 1 0 {name=R35
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 2990 220 1 0 {name=R36
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 2930 220 1 0 {name=R37
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 2930 200 2 1 {name=l127 lab=GND}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3360 660 1 0 {name=C146 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 -170 1 0 {name=C147 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 -200 1 0 {name=C148 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 -100 1 0 {name=C149 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 -130 1 0 {name=C150 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 -40 1 0 {name=C151 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 -70 1 0 {name=C152 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 20 1 0 {name=C153 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 -10 1 0 {name=C154 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 90 1 0 {name=C155 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 60 1 0 {name=C156 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 150 1 0 {name=C157 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 120 1 0 {name=C158 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 210 1 0 {name=C159 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 180 1 0 {name=C160 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 270 1 0 {name=C161 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 240 1 0 {name=C162 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 430 1 0 {name=C163 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 400 1 0 {name=C164 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 500 1 0 {name=C165 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 470 1 0 {name=C166 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 560 1 0 {name=C167 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 530 1 0 {name=C168 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 620 1 0 {name=C169 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 590 1 0 {name=C170 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 690 1 0 {name=C171 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 660 1 0 {name=C172 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 750 1 0 {name=C173 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 720 1 0 {name=C174 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 810 1 0 {name=C175 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 780 1 0 {name=C176 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 870 1 0 {name=C177 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2530 840 1 0 {name=C178 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {madvlsi/gnd.sym} 2460 60 1 1 {name=l128 lab=GND}
C {madvlsi/gnd.sym} 2460 400 1 1 {name=l129 lab=GND}
C {devices/lab_pin.sym} 4220 450 1 0 {name=l130 sig_type=std_logic lab=Vouts}
C {devices/lab_pin.sym} 3860 580 1 0 {name=l131 sig_type=std_logic lab=Vouts}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 480 1 0 {name=C179 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 450 1 0 {name=C180 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 550 1 0 {name=C181 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 520 1 0 {name=C182 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 610 1 0 {name=C183 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 580 1 0 {name=C184 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 670 1 0 {name=C185 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 640 1 0 {name=C186 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 740 1 0 {name=C187 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 710 1 0 {name=C188 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 800 1 0 {name=C189 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 770 1 0 {name=C190 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 860 1 0 {name=C191 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 830 1 0 {name=C192 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 920 1 0 {name=C193 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 890 1 0 {name=C194 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 3920 1300 3 0 {name=l132 sig_type=std_logic lab=Vouts}
C {devices/lab_pin.sym} 3840 -410 3 0 {name=l133 sig_type=std_logic lab=Vouts}
C {devices/lab_pin.sym} 3780 -1130 1 0 {name=l134 sig_type=std_logic lab=Vouts}
C {devices/lab_pin.sym} 4140 -1260 1 0 {name=l135 sig_type=std_logic lab=Vouts}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2300 190 3 0 {name=C195 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2300 130 3 0 {name=C196 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2300 370 3 0 {name=C197 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2300 310 3 0 {name=C198 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4240 50 3 0 {name=C199 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4240 -10 3 0 {name=C200 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4240 230 3 0 {name=C201 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4240 170 3 0 {name=C202 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 -230 1 0 {name=C203 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 -260 1 0 {name=C204 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 -160 1 0 {name=C205 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 -190 1 0 {name=C206 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 -100 1 0 {name=C207 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 -130 1 0 {name=C208 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 -40 1 0 {name=C209 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 -70 1 0 {name=C210 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 30 1 0 {name=C211 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 0 1 0 {name=C212 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 90 1 0 {name=C213 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 60 1 0 {name=C214 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 150 1 0 {name=C215 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 120 1 0 {name=C216 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 210 1 0 {name=C217 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 180 1 0 {name=C218 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 370 1 0 {name=C219 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 340 1 0 {name=C220 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 440 1 0 {name=C221 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 410 1 0 {name=C222 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 500 1 0 {name=C223 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 470 1 0 {name=C224 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 560 1 0 {name=C225 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 530 1 0 {name=C226 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 630 1 0 {name=C227 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 600 1 0 {name=C228 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 690 1 0 {name=C229 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 660 1 0 {name=C230 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 750 1 0 {name=C231 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 720 1 0 {name=C232 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 810 1 0 {name=C233 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4590 780 1 0 {name=C234 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {madvlsi/gnd.sym} 4520 0 1 1 {name=l136 lab=GND}
C {madvlsi/gnd.sym} 4520 340 1 1 {name=l137 lab=GND}
C {devices/lab_pin.sym} 4420 580 2 0 {name=l138 sig_type=std_logic lab=Vouts}
C {devices/lab_pin.sym} 4340 -1130 2 0 {name=l139 sig_type=std_logic lab=Vouts}
C {devices/lab_pin.sym} 5420 -130 0 0 {name=l141 sig_type=std_logic lab=Vref_adc
}
C {devices/lab_pin.sym} 5670 -130 1 0 {name=l143 sig_type=std_logic lab=Vflag}
C {devices/lab_pin.sym} 5720 -110 0 0 {name=l144 sig_type=std_logic lab=adc_CLK}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/and2.sym} 5690 -120 0 0 {name=X38}
C {madvlsi/vdd.sym} 5750 -150 0 0 {name=l145 lab=VDD}
C {madvlsi/gnd.sym} 5750 -90 0 0 {name=l146 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 5990 320 0 0 {name=X39}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6190 320 0 0 {name=X40}
C {devices/lab_pin.sym} 5880 400 0 0 {name=l147 sig_type=std_logic lab=Vflag}
C {devices/lab_pin.sym} 6040 290 0 0 {name=l148 sig_type=std_logic lab=Q0}
C {devices/lab_pin.sym} 6240 290 0 0 {name=l149 sig_type=std_logic lab=Q1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6400 320 0 0 {name=X47}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6600 320 0 0 {name=X48}
C {devices/lab_pin.sym} 6450 290 0 0 {name=l150 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 6650 290 0 0 {name=l151 sig_type=std_logic lab=Q3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6800 320 0 0 {name=X49}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 7000 320 0 0 {name=X50}
C {devices/lab_pin.sym} 6850 290 0 0 {name=l152 sig_type=std_logic lab=Q4}
C {devices/lab_pin.sym} 7050 290 0 0 {name=l153 sig_type=std_logic lab=Q5}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 7220 320 0 0 {name=X51}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 7420 320 0 0 {name=X52}
C {devices/lab_pin.sym} 7270 290 0 0 {name=l154 sig_type=std_logic lab=Q6}
C {devices/lab_pin.sym} 7470 290 0 0 {name=l155 sig_type=std_logic lab=Q7}
C {devices/lab_pin.sym} 6130 290 2 0 {name=l156 sig_type=std_logic lab=Qout0}
C {devices/lab_pin.sym} 6330 290 2 0 {name=l157 sig_type=std_logic lab=Qout1}
C {devices/lab_pin.sym} 6540 290 2 0 {name=l158 sig_type=std_logic lab=Qout2}
C {devices/lab_pin.sym} 6740 290 2 0 {name=l159 sig_type=std_logic lab=Qout3}
C {devices/lab_pin.sym} 6940 290 2 0 {name=l160 sig_type=std_logic lab=Qout4}
C {devices/lab_pin.sym} 7140 290 2 0 {name=l161 sig_type=std_logic lab=Qout5}
C {devices/lab_pin.sym} 7360 290 2 0 {name=l162 sig_type=std_logic lab=Qout6}
C {devices/lab_pin.sym} 7560 290 2 0 {name=l163 sig_type=std_logic lab=Qout7}
C {devices/lab_pin.sym} 6150 -560 1 0 {name=l164 sig_type=std_logic lab=Q0}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 5990 -320 0 0 {name=X43}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6110 -320 0 0 {name=X44}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 6220 -180 3 0 {name=X45 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 6180 -180 3 0 {name=l165 lab=VDD}
C {madvlsi/gnd.sym} 6260 -180 3 0 {name=l166 lab=GND}
C {devices/lab_pin.sym} 6510 -560 1 0 {name=l167 sig_type=std_logic lab=Q1}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6360 -320 0 0 {name=X46}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6480 -320 0 0 {name=X53}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 6470 -200 3 0 {name=X54 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 6430 -200 3 0 {name=l168 lab=VDD}
C {madvlsi/gnd.sym} 6510 -200 3 0 {name=l169 lab=GND}
C {devices/lab_pin.sym} 6310 -300 2 0 {name=l170 sig_type=std_logic lab=Qn0}
C {devices/lab_pin.sym} 6680 -300 2 0 {name=l171 sig_type=std_logic lab=Qn1}
C {devices/lab_pin.sym} 6870 -560 1 0 {name=l172 sig_type=std_logic lab=Q2}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6730 -320 0 0 {name=X55}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 6850 -320 0 0 {name=X56}
C {devices/lab_pin.sym} 7050 -300 2 0 {name=l173 sig_type=std_logic lab=Qn2}
C {devices/lab_pin.sym} 7240 -560 1 0 {name=l174 sig_type=std_logic lab=Q3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 7100 -320 0 0 {name=X57}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 7220 -320 0 0 {name=X58}
C {devices/lab_pin.sym} 7420 -300 2 0 {name=l175 sig_type=std_logic lab=Qn3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 6840 -200 3 0 {name=X61 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 6800 -200 3 0 {name=l176 lab=VDD}
C {madvlsi/gnd.sym} 6880 -200 3 0 {name=l177 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 7210 -200 3 0 {name=X62 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 7170 -200 3 0 {name=l178 lab=VDD}
C {madvlsi/gnd.sym} 7250 -200 3 0 {name=l179 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 6150 -500 3 0 {name=X64 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 6110 -500 3 0 {name=l180 lab=VDD}
C {madvlsi/gnd.sym} 6190 -500 3 0 {name=l181 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 6510 -500 3 0 {name=X65 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 6470 -500 3 0 {name=l182 lab=VDD}
C {madvlsi/gnd.sym} 6550 -500 3 0 {name=l183 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 6870 -500 3 0 {name=X66 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 6830 -500 3 0 {name=l184 lab=VDD}
C {madvlsi/gnd.sym} 6910 -500 3 0 {name=l185 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 7240 -500 3 0 {name=X67 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 7200 -500 3 0 {name=l186 lab=VDD}
C {madvlsi/gnd.sym} 7280 -500 3 0 {name=l187 lab=GND}
C {devices/lab_pin.sym} 6310 -120 0 0 {name=l188 sig_type=std_logic lab=Q0}
C {devices/lab_pin.sym} 6680 -120 0 0 {name=l189 sig_type=std_logic lab=Q1}
C {devices/lab_pin.sym} 7050 -120 0 0 {name=l190 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 7420 -120 0 0 {name=l191 sig_type=std_logic lab=Q3}
C {devices/lab_pin.sym} 6040 -320 0 0 {name=l192 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6040 -290 0 0 {name=l193 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6160 -290 0 0 {name=l194 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6160 -320 0 0 {name=l195 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6410 -320 0 0 {name=l196 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6410 -290 0 0 {name=l197 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6780 -320 0 0 {name=l198 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6780 -290 0 0 {name=l199 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 7150 -320 0 0 {name=l200 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 7150 -290 0 0 {name=l201 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6530 -290 0 0 {name=l202 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6530 -320 0 0 {name=l203 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6900 -290 0 0 {name=l204 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6900 -320 0 0 {name=l205 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 7270 -290 0 0 {name=l206 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 7270 -320 0 0 {name=l207 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 7610 -560 1 0 {name=l208 sig_type=std_logic lab=Q4}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 7470 -320 0 0 {name=X41}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 7590 -320 0 0 {name=X42}
C {devices/lab_pin.sym} 7790 -300 2 0 {name=l209 sig_type=std_logic lab=Qn4}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 7580 -200 3 0 {name=X59 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 7540 -200 3 0 {name=l210 lab=VDD}
C {madvlsi/gnd.sym} 7620 -200 3 0 {name=l211 lab=GND}
C {devices/lab_pin.sym} 7420 -120 0 0 {name=l212 sig_type=std_logic lab=Q3}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 7610 -500 3 0 {name=X60 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 7570 -500 3 0 {name=l213 lab=VDD}
C {madvlsi/gnd.sym} 7650 -500 3 0 {name=l214 lab=GND}
C {devices/lab_pin.sym} 7520 -320 0 0 {name=l215 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 7520 -290 0 0 {name=l216 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 7640 -290 0 0 {name=l217 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 7640 -320 0 0 {name=l218 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 7990 -560 1 0 {name=l219 sig_type=std_logic lab=Q5}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 7840 -320 0 0 {name=X63}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 7960 -320 0 0 {name=X68}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 7950 -200 3 0 {name=X69 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 7910 -200 3 0 {name=l220 lab=VDD}
C {madvlsi/gnd.sym} 7990 -200 3 0 {name=l221 lab=GND}
C {devices/lab_pin.sym} 8160 -300 2 0 {name=l222 sig_type=std_logic lab=Qn5}
C {devices/lab_pin.sym} 8350 -560 1 0 {name=l223 sig_type=std_logic lab=Q6}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 8210 -320 0 0 {name=X70}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 8330 -320 0 0 {name=X71}
C {devices/lab_pin.sym} 8530 -300 2 0 {name=l224 sig_type=std_logic lab=Qn6}
C {devices/lab_pin.sym} 8720 -560 1 0 {name=l225 sig_type=std_logic lab=Q7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 8580 -320 0 0 {name=X72}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 8700 -320 0 0 {name=X73}
C {devices/lab_pin.sym} 8900 -300 2 0 {name=l226 sig_type=std_logic lab=Qn7}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 8320 -200 3 0 {name=X74 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 8280 -200 3 0 {name=l227 lab=VDD}
C {madvlsi/gnd.sym} 8360 -200 3 0 {name=l228 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 8690 -200 3 0 {name=X75 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 8650 -200 3 0 {name=l229 lab=VDD}
C {madvlsi/gnd.sym} 8730 -200 3 0 {name=l230 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 7990 -500 3 0 {name=X76 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 7950 -500 3 0 {name=l231 lab=VDD}
C {madvlsi/gnd.sym} 8030 -500 3 0 {name=l232 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 8350 -500 3 0 {name=X77 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 8310 -500 3 0 {name=l233 lab=VDD}
C {madvlsi/gnd.sym} 8390 -500 3 0 {name=l234 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 8720 -500 3 0 {name=X78 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 8680 -500 3 0 {name=l235 lab=VDD}
C {madvlsi/gnd.sym} 8760 -500 3 0 {name=l236 lab=GND}
C {devices/lab_pin.sym} 7790 -120 0 0 {name=l237 sig_type=std_logic lab=Q4}
C {devices/lab_pin.sym} 8160 -120 0 0 {name=l238 sig_type=std_logic lab=Q5}
C {devices/lab_pin.sym} 8530 -120 0 0 {name=l239 sig_type=std_logic lab=Q6}
C {devices/lab_pin.sym} 7890 -320 0 0 {name=l240 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 7890 -290 0 0 {name=l241 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 8260 -320 0 0 {name=l242 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 8260 -290 0 0 {name=l243 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 8630 -320 0 0 {name=l244 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 8630 -290 0 0 {name=l245 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 8010 -290 0 0 {name=l246 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 8010 -320 0 0 {name=l247 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 8380 -290 0 0 {name=l248 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 8380 -320 0 0 {name=l249 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 8750 -290 0 0 {name=l250 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 8750 -320 0 0 {name=l251 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 9080 -560 1 0 {name=l252 sig_type=std_logic lab=Q8}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 8940 -320 0 0 {name=X79}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/dff.sym} 9060 -320 0 0 {name=X80}
C {devices/lab_pin.sym} 9260 -300 2 0 {name=l253 sig_type=std_logic lab=Qn8}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 9050 -200 3 0 {name=X81 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 9010 -200 3 0 {name=l254 lab=VDD}
C {madvlsi/gnd.sym} 9090 -200 3 0 {name=l255 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/inverter.sym} 9080 -500 3 0 {name=X82 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {madvlsi/vdd.sym} 9040 -500 3 0 {name=l256 lab=VDD}
C {madvlsi/gnd.sym} 9120 -500 3 0 {name=l257 lab=GND}
C {devices/lab_pin.sym} 8890 -120 0 0 {name=l258 sig_type=std_logic lab=Q7}
C {devices/lab_pin.sym} 8990 -320 0 0 {name=l259 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 8990 -290 0 0 {name=l260 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 9110 -290 0 0 {name=l261 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 9110 -320 0 0 {name=l262 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6040 320 0 0 {name=l263 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6040 350 0 0 {name=l264 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6240 320 0 0 {name=l265 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6240 350 0 0 {name=l266 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6450 320 0 0 {name=l267 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6450 350 0 0 {name=l268 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6650 320 0 0 {name=l269 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6650 350 0 0 {name=l270 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 6850 320 0 0 {name=l271 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 6850 350 0 0 {name=l272 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 7050 320 0 0 {name=l273 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 7050 350 0 0 {name=l274 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 7270 320 0 0 {name=l275 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 7270 350 0 0 {name=l276 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 7470 320 0 0 {name=l277 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 7470 350 0 0 {name=l278 sig_type=std_logic lab=C}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 5460 90 0 0 {name=X83 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {devices/lab_pin.sym} 5470 110 3 0 {name=l279 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 5450 110 3 0 {name=l280 sig_type=std_logic lab=NP}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/switch.sym} 5580 90 0 0 {name=X84 Wp=1 Lp=0.15 WW=1 LL=0.15}
C {devices/lab_pin.sym} 5590 110 3 0 {name=l282 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 5570 110 3 0 {name=l283 sig_type=std_logic lab=NP}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage_lvs.sym} 5460 -120 0 0 {name=X85}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/comparator_lvs.sym} 5600 -130 0 0 {name=X86}
C {madvlsi/pmos3.sym} 5880 -170 0 0 {name=M25
L=0.15
W=2
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 5880 -200 0 0 {name=l284 lab=VDD}
C {madvlsi/nmos3.sym} 5880 -70 0 0 {name=M26
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 5880 -40 0 0 {name=l285 lab=GND}
C {madvlsi/pmos3.sym} 6010 -170 0 0 {name=M27
L=0.15
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 6010 -200 0 0 {name=l286 lab=VDD}
C {madvlsi/nmos3.sym} 6010 -70 0 0 {name=M28
L=0.15
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 6010 -40 0 0 {name=l287 lab=GND}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/mux2.sym} 5110 0 0 0 {name=X87}
C {devices/lab_pin.sym} 5110 40 3 0 {name=l288 sig_type=std_logic lab=Q8}
C {devices/lab_pin.sym} 5560 -140 0 0 {name=l140 sig_type=std_logic lab=Vref_adc
}
C {madvlsi/gnd.sym} 5070 20 1 0 {name=l142 lab=GND}
C {devices/lab_pin.sym} 5610 90 2 0 {name=l281 sig_type=std_logic lab=Vref_adc
}
C {devices/lab_pin.sym} 2190 1040 0 0 {name=l289 sig_type=std_logic lab=Vpp2}
C {devices/lab_pin.sym} 2190 1250 0 0 {name=l290 sig_type=std_logic lab=Vnn2}
C {devices/lab_pin.sym} 1800 -790 3 0 {name=l291 sig_type=std_logic lab=net9}
C {devices/lab_pin.sym} 1880 920 3 0 {name=l292 sig_type=std_logic lab=net12}
