v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 1030 610 1030 660 { lab=Vouts}
N 950 620 950 660 { lab=#net1}
N 930 600 950 600 { lab=#net2}
N 950 660 950 700 { lab=#net1}
N 950 590 950 600 { lab=#net2}
N 950 700 950 1040 { lab=#net1}
N 950 1040 1030 1040 { lab=#net1}
N 1030 1020 1030 1040 { lab=#net1}
N 1010 690 1010 990 { lab=GND}
N 930 260 930 560 { lab=GND}
N 940 1040 950 1040 { lab=#net1}
N 480 670 900 670 { lab=GND}
N 450 1040 880 1040 { lab=GND}
N 930 690 950 690 { lab=#net1}
N 480 580 900 580 { lab=GND}
N 450 690 450 1040 { lab=GND}
N 940 1170 950 1170 { lab=#net1}
N 950 1040 950 1170 { lab=#net1}
N 860 1170 880 1170 { lab=GND}
N 860 1040 860 1170 { lab=GND}
C {devices/lab_pin.sym} 1030 610 2 0 {name=l9 sig_type=std_logic lab=Vouts}
C {madvlsi/gnd.sym} 450 690 1 1 {name=l14 lab=GND}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 1170 1 0 {name=C1 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
C {/home/madvlsi/Documents/MADVLSI-Final_Project/schematic/selfbiasedcascode2stage_lvs.sym} 990 610 0 0 {name=X1}
C {sky130_fd_pr/res_xhigh_po.sym} 1030 690 0 0 {name=R1
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 900 690 1 0 {name=R4
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1030 750 0 0 {name=R5
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1030 810 0 0 {name=R6
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1030 870 0 0 {name=R7
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1030 930 0 0 {name=R8
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 1030 990 0 0 {name=R9
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 1010 990 1 1 {name=l5 lab=GND}
C {sky130_fd_pr/res_xhigh_po.sym} 950 260 0 0 {name=R10
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 950 320 0 0 {name=R11
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 950 380 0 0 {name=R12
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 950 440 0 0 {name=R13
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 950 500 0 0 {name=R14
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 950 560 0 0 {name=R15
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 930 260 1 1 {name=l1 lab=GND}
C {madvlsi/gnd.sym} 950 230 2 1 {name=l2 lab=GND}
C {sky130_fd_pr/res_xhigh_po.sym} 840 690 1 0 {name=R2
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 780 690 1 0 {name=R16
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 720 690 1 0 {name=R17
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 660 690 1 0 {name=R18
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 600 690 1 0 {name=R19
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 540 690 1 0 {name=R20
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 480 690 1 0 {name=R21
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 480 670 2 1 {name=l7 lab=GND}
C {sky130_fd_pr/res_xhigh_po.sym} 900 600 1 0 {name=R3
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 840 600 1 0 {name=R22
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 780 600 1 0 {name=R23
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 720 600 1 0 {name=R24
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 660 600 1 0 {name=R25
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 600 600 1 0 {name=R26
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 540 600 1 0 {name=R27
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po.sym} 480 600 1 0 {name=R28
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 480 580 2 1 {name=l3 lab=GND}
C {sky130_fd_pr/cap_mim_m3_1.sym} 910 1040 1 0 {name=C2 model=cap_mim_m3_1 W=5 L=5 MF=1 spiceprefix=X}
