v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {/home/madvlsi/skywater/xschem_sky130/sky130_fd_pr/res_xhigh_po.sym} -780 80 0 0 {name=R2
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} -800 80 0 0 {name=l14 lab=GND}
